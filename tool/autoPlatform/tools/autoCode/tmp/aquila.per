config 16. 8.

tree "aibaux"

width 18.

group d:0xD401E800++0x03
    line.long 0x00 "AIB_NAND_IO_REG,AIB NAND I/O Domain Control Register"
        bitfld.long 0x00 6.--7. " AIB_NAND_IO_DCS  ,controls the output driver pull up/down network driven strength by selecting proper number of nmos/pmos fingers to turned on" "0,1,2,3"

group d:0xD401E804++0x03
    line.long 0x00 "AIB_ANT_IO_REG,AIB ANT I/O Domain Control Register"
        bitfld.long 0x00 3. " SL28             ,this field is the io input schmitt trigger control.   0 = disable    1 = enable" "0,1"
        bitfld.long 0x00 2. "     V18EN29  ,1.8v enable to pad   0 = 3.0v   1 = 1.8v" "0,1"
        bitfld.long 0x00 0. "  SL31  ,this field control the io output slew rate." "0,1"

group d:0xD401E808++0x03
    line.long 0x00 "AIB_GPIO1_IO_REG,AIB GPIO 1 I/O Domain Control Register"
        bitfld.long 0x00 6.--7. " AIB_GPIO_IO_DCS  ,controls the output driver pull up/down network driven strength by selecting proper number of nmos/pmos fingers to turned on" "0,1,2,3"

group d:0xD401E80C++0x03
    line.long 0x00 "AIB_GPIO2_IO_REG,AIB GPIO 2 I/O Domain Control Register"
        bitfld.long 0x00 2. " V18EN47          ,1.8v enable to pad" "0,1"
        bitfld.long 0x00 0. "     PDB      ,vddiox_pbgen pad power down  0 = power down" "0,1"

group d:0xD401E814++0x03
    line.long 0x00 "AIB_GPIO4_IO_REG,AIB GPIO4 I/O Domain Control Register"
        bitfld.long 0x00 6.--7. " AIB_GPIO4_IO_DCS ,controls the output driver pull up/down network driven strength by selecting proper number of nmos/pmos fingers to turned on" "0,1,2,3"

group d:0xD401E818++0x03
    line.long 0x00 "AIB_MEM_IO_REG,AIB MEM I/O Domain Control Register"

group d:0xD401E81C++0x03
    line.long 0x00 "AIB_MMC1_IO_REG,AIB MMC 1 I/O Domain Control Register"
        bitfld.long 0x00 3. " SL72             ,this field is the io input schmitt trigger control.   0 = disable    1 = enable" "0,1"
        bitfld.long 0x00 2. "     V18EN73  ,1.8v enable to pad   0 = 3.0v   1 = 1.8v" "0,1"
        bitfld.long 0x00 0. "  SL75  ,this field control the io output slew rate." "0,1"

group d:0xD401E824++0x03
    line.long 0x00 "AIB_PMIC1_IO_REG,AIB PMIC 1 I/O Domain Control Register"
        bitfld.long 0x00 6.--7. " AIB_PMIC1_IO_DCS ,controls the output driver pull up/down network driven strength by selecting proper number of nmos/pmos fingers to turned on" "0,1,2,3"

group d:0xD401E828++0x03
    line.long 0x00 "AIB_PMIC2_IO_REG,AIB PMIC 2 I/O Domain Control Register"
        bitfld.long 0x00 6.--7. " AIB_PMIC2_IO_DCS ,controls the output driver pull up/down network driven strength by selecting proper number of nmos/pmos fingers to turned on" "0,1,2,3"

group d:0xD401E82C++0x03
    line.long 0x00 "AIB_USIM_IO_REG,AIB USIM I/O Domain Control Register"
        bitfld.long 0x00 3. " SL99             ,this field is the io input schmitt trigger control.   0 = disable    1 = enable" "0,1"
        bitfld.long 0x00 2. "     V18EN100 ,1.8v enable to pad   0 = 3.0v   1 = 1.8v" "0,1"
        bitfld.long 0x00 0. "  SL102 ,this field control the io output slew rate." "0,1"

group d:0xD401E830++0x03
    line.long 0x00 "AIB_GPIO3_IO_REG,AIB GPIO3 I/O Domain Control Register"
        bitfld.long 0x00 6.--7. " AIB_GPIO3_IO_DCS ,controls the output driver pull up/down network driven strength by selecting proper number of nmos/pmos fingers to turned on" "0,1,2,3"

group d:0xD401EC00++0x03
    line.long 0x00 "AIB_AP_CFG_15_0,AIB AP config [15:0]"
        hexmask.long.word 0x00 0.--15. 1. " AIB_AP_CFG_15_0  ,aib ap_cfg override [15:0]"

group d:0xD401EC04++0x03
    line.long 0x00 "AIB_AP_CFG_31_16,AIB AP config [31:16]"
        hexmask.long.word 0x00 0.--15. 1. " AIB_AP_CFG_31_16 ,aib ap_cfg override [31:16]"

group d:0xD401EC08++0x03
    line.long 0x00 "AIB_AP_CFG_47_32,AIB AP config [47:32]"
        hexmask.long.word 0x00 0.--15. 1. " AIB_AP_CFG_47_32 ,aib ap_cfg override [47:32]"

group d:0xD401EC0C++0x03
    line.long 0x00 "AIB_AP_CFG_63_48,AIB AP config [63:48]"
        hexmask.long.word 0x00 0.--15. 1. " AIB_AP_CFG_63_48 ,aib ap_cfg override [63:48]"

group d:0xD401EC10++0x03
    line.long 0x00 "AIB_AP_CFG_79_64,AIB AP config [79:64]"
        hexmask.long.word 0x00 0.--15. 1. " AIB_AP_CFG_79_64 ,aib ap_cfg override [79:64]"

group d:0xD401EC14++0x03
    line.long 0x00 "AIB_CP_CFG_15_0,AIB CP config [15:0]"
        hexmask.long.word 0x00 0.--15. 1. " AIB_CP_CFG_15_0  ,aib cp_cfg override [15:0]"

tree.end

tree "rtc"

width 9.

group d:0xD4010000++0x03
    line.long 0x00 "RTC_CNR,RTC Counter Register"
        hexmask.long 0x00 0.--31. 1. " TC          ,time count"

group d:0xD4010004++0x03
    line.long 0x00 "RTC_AR,RTC Alarm Register"
        hexmask.long 0x00 0.--31. 1. " AT          ,alarm time"

group d:0xD4010008++0x03
    line.long 0x00 "RTC_SR,RTC Status Register"
        bitfld.long 0x00 3. " HZE         ,1-hz interrupt enable  0 = the 1-hz interrupt is not enabled  1 = the 1-hz interrupt is enabled" "0,1"
        bitfld.long 0x00 2. "         ALE   ,rtc alarm interrupt enable  0 = the rtc alarm interrupt is not enabled  1 = the rtc alarm interrupt is enabled  this interrupt must be cleared just prior to enabling it since it remembers past events (matches) even when not enabled." "0,1"
        bitfld.long 0x00 1. "     HZ      ,1-hz rising-edge detected  0 = no rising edge has been detected  1 = a rising edge has been detected and the <1-hz interrupt enable> field is set  writing 1 to this field clears the 1-hz level interrupt (rtc_hzclk and rtc_hzclk_int)." "0,1"
        bitfld.long 0x00 0. "     AL ,rtc alarm detected  0 = no alarm has been detected  1 = an alarm has been detected (rtc counter register matches rtc alarm register) and the <rtc alarm interrupt enable> field is set  writing 1s to this field clears the alarm level interrupt (rtc_slp_alarm)." "0,1"

group d:0xD401000C++0x03
    line.long 0x00 "RTC_TR,RTC Trim Register"
        bitfld.long 0x00 31. " LCK         ,locking bit for the trim value" "0,1"
        hexmask.long.word 0x00 16.--25. 1. "         D9_D0 ,trim delete count  this value represents the number of 32 khz clocks to delete when clock trimming begins."
        hexmask.long.word 0x00 0.--15. 1. "  C150_C0 ,clock divider count  this value is the integer portion of the clock trim logic."

group d:0xD4010010++0x03
    line.long 0x00 "RTC_PR,RTC Control Register"
        bitfld.long 0x00 0. " SW_ALARM    ,controls the alarm signal  0 = is off (alarm negated)  1 = is on (alarm asserted)" "0,1"

group d:0xD4010014++0x03
    line.long 0x00 "RTC_BRn,RTC Backup Registers"
        hexmask.long 0x00 0.--31. 1. " RTCS_DATA77 ,backup data"

tree.end

tree "dma"

width 16.

group d:0xD4000000++0x03
    line.long 0x00 "DMA_CSR015,DMA Channel Control/Status Registers 0-15"
        bitfld.long 0x00 31. " DM_RUN15                 ,run  this field allows software to start or stop the channel. if it is cleared in the middle of the burst, the burst is completed before the channel stops. setting this field starts the stopped channel.  if the channel is in a descriptor-fetch transfer and this field is set before writing a valid descriptor address to the dma descriptor address registers, no-descriptor fetch occurs.  this bit is reset as soon as it is cleared and when the channel stops normally. after the channel stops, the <stop interrupt> field is set. the <stop interrupt> field must be polled to read the channel status or to set the <stop interrupt enabled> field and expect an interrupt after the channel stops.  0 = stops the channel  1 = starts the channel" "0,1"
        bitfld.long 0x00 30. "         DM_NODESCFETCH16 ,no-descriptor fetch  this bit controls whether or not a channel has a descriptor. if this field is set, the channel is considered a simple channel with no descriptors. in this case, the dma does not initiate descriptor fetches when software sets the <run> field or when the byte count for the current transfer reaches zero.  to program the channel for a no-descriptor-fetch transfer, software must set, then write to the individual dma source address registers 0-31, dma target address registers 0-31, and dma command registers 0-31 for that channel. the dma descriptor address registers are not used in this mode and must not be written. the <run> field must be set to allow the channel to start the transfer.   if this field is cleared, the dmac initiates descriptor-fetches when software writes to the dma descriptor address registers, when the byte count for the current transfer reaches zero.  0 = descriptor-fetch transfer  1 = no-descriptor-fetch transfer" "0,1"
        bitfld.long 0x00 29. "   DM_STOPIRQEN17   ,stop interrupt enabled  this field enables the interrupt when the <stop interrupt> field is set. if this field is cleared, no interrupt is generated after the channel stops.  the <stop interrupt> field is set after system reset de-assertion. thus, if <stop interrupt> is set before the channel is started, an interrupt is generated.  0 = no interrupt if the channel is in uninitialized or stopped state  1 = interrupt enabled if the channel is in uninitialized or stopped state" "0,1"
        bitfld.long 0x00 28. "     DM_EORIRQEN18  ,setting the end-of-receive interrupt enable  this field triggers an interrupt on an eor condition. clearing this bit does not generate an eor-related interrupt.  0 = interrupt not triggered even if the <end of receive interrupt> field is set  1 = enable interrupt if <end of receive interrupt> is set" "0,1"
        textline "                          "
        bitfld.long 0x00 27. "DM_EORJMPEN19            ,jump to the next descriptor on eor  this field controls the descriptor flow when the mapped peripheral signals an eor to the dmac. see descriptor behavior on end-of-receive (eor) figure for the behavior of the descriptor during this condition.  this control bit has no effect on the channel for no-descriptor-fetch transfers (<no-descriptor fetch> set). the dmac completes the peripheral-to-memory data transfer on an eor, regardless of this field.  0 = dmac continues to hold the current descriptor and waits until the mapped peripheral makes another receive request.  1 = dmac jumps to the channel's next descriptor on receiving an eor from the mapped peripheral." "0,1"
        bitfld.long 0x00 26. "         DM_EORSTOPEN20   ,stop channel on eor  this field has no effect on the channel for no-descriptor-fetch transfers (<no-descriptor fetch> set). the dmac completes the peripheral-to-memory data transfer on an eor, regardless of this field.  setting this field causes the dmac to stop the channel on an eor and set the corresponding <stop interrupt> field. if the <stop interrupt enabled> field is set when this field is set, an interrupt occurs.  see descriptor behavior on end-of-receive (eor) figure for the behavior of the descriptor.  0 = dmac continues to hold the current descriptor and waits until the mapped peripheral makes another receive request.  1 = dmac stops the channel that received an eor from the mapped peripheral." "0,1"
        bitfld.long 0x00 25. "   DM_SETCMPST21    ,set descriptor compare status  this field partially controls <descriptor compare status>. setting this bit sets <descriptor compare status>. clearing this field has no effect on <descriptor compare status>. software can set the <descriptor compare status> even if the descriptor is not configured in the compare mode (<descriptor compare enable> field in dma command registers 0-31 = 0).   0 = no effect on <descriptor compare status>  1 = set <descriptor compare status>" "0,1"
        bitfld.long 0x00 24. "     DM_CLRCMPST22  ,clear descriptor compare status  this field partially controls <descriptor compare status>. setting this field clears <descriptor compare status>. clearing this field has no effect on <descriptor compare status>. software can set <descriptor compare status> even if the descriptor is not configured in the compare mode.  0 = no effect on <descriptor compare status>  1 = clear <descriptor compare status>" "0,1"
        textline "                          "
        bitfld.long 0x00 23. "DM_RASIRQEN23            ,request after channel stopped interrupt enable  0 = interrupt not triggered when a peripheral asserts a dma request after the channel has stopped  1 = set interrupt bit for that channel in the <channel interrupt> in the dma interrupt register when a peripheral asserts a dma request after the channel has stopped." "0,1"
        bitfld.long 0x00 22. "         DM_MASKRUN24     ,mask <run> during a programmed i/o write to this register  0 = software (programmed i/o write) can modify <run> during a write transaction  1 = software (programmed i/o write) can not modify <run> during a write transaction" "0,1"
        bitfld.long 0x00 21. "   LPAE_EN          ,long physical address extension enable this bit enable long physical address extension access. lpae_en bit applies to both descriptor mode and nondescriptor mode. 0 = lpae feature is disabled. for both descriptor mode, there is no need to program dma_dadr_h register. descriptors should still be 4 words(32bits per word, aligned on a 16-byte boundary in memory). for non-descriptor mode, there is no need to program dma_tadr_h and dma_sadr_h registers. sw need no change. 1 = lpae feature is enabled. for descriptor mode, sw must program dma_dadr_h register and prepare the 8 words (32bits per word, aligned on a 32-byte boundary in memory) descriptors in memory. for non-descriptor mode, sw must program dma_tadr_h and dma_sadr_h registers. lpae is a feature that can be turned on and off at any dma transfer. any non-lpae dma transfers can be interleaved with lpae dma transfers, or vice versa." "0,1"
        bitfld.long 0x00 10. "     DM_CMPST27     ,descriptor compare status  this field indicates the most recent status of the source and target compare operation. it is set on a successful compare of the source and target fields. an unsuccessful comparison clears it. refer to the description of <addrmode> in the dma command registers 0-31 for the various addressing modes used for this comparison. for details regarding the descriptor compare mode, refer to <descriptor compare enable> in the dma command registers 0 to 31.  the dmac updates cmpst only in descriptor compare mode (<descriptor compare enable> = 1).  this field can be set and cleared by setting <set descriptor compare status> and <clear descriptor compare status>, respectively.  if software attempts to concurrently set and clear this field by setting both <set descriptor compare status> and <clear descriptor compare status>, <set descriptor compare status> has higher precedence. modifying this bit after <run> is set and the channel is actively running leads to faulty behavior of the descriptor chain. the channel must be stopped before setting or clearing this field.  0 = indicates an unsuccessful address compare in descriptor-compare mode.  1 = indicates a successful compare of the current descriptor source and target addresses in descriptor-compare mode." "0,1"
        textline "                          "
        bitfld.long 0x00 9. "DM_EORINT28              ,end of receive interrupt  eorint pertains only to internal peripherals. this field indicates the status of the mapped peripheral's receive data. it is set after the dmac reads out the last trailing sample from the peripheral's receive fifo. the descriptor behavior on end-of-receive (eor) figure illustrates the behavior of the descriptor during this condition.  0 = dma continues with current descriptor because the internal peripheral is still actively receiving data  1 = channel mapped internal peripheral has no data remaining in its receive fifo and has completed all receive transactions. refer to the description of <jump to the next descriptor on eor> for the behavior of the dmac during this condition." "0,1"
        bitfld.long 0x00 8. "         DM_REQPEND30     ,request pending  this field indicates a pending request for the dma channel.  reqpend is cleared for a channel if that channel has no pending request or the request has just been issued to the memory interface in case of a read or write from the external companion chip to memory.   if dreq assertion sets reqpend and <run> is cleared to stop that channel, reqpend and the internal registers that hold the dreq assertion information, do not remain set. if the channel is restarted, reqpend must be reset by a descriptor that transfers dummy data (for example, a memory-to-memory transfer from a temporary location to another temporary location).   0 = no request is pending for the channel  1 = a request is pending for the channel" "0,1"
        bitfld.long 0x00 4. "   DM_RASINTR32     ,request after channel stopped  0 = no interrupt   1 = interrupt caused due to a request made by the peripheral after the respective channel stopped  this bit is reset by writing a 1." "0,1"
        bitfld.long 0x00 3. "     DM_STOPINTR33  ,stop interrupt  this is a read-only bit that reflects the channel state.  software must clear <stop interrupt enabled> to reset the interrupt. reprogramming the dma descriptor address registers and setting <run> restarts the channel.  0 = channel is running  1 = channel is in uninitialized or stopped state. if <stop interrupt enabled> is set, the dmac generates an interrupt." "0,1"
        textline "                          "
        bitfld.long 0x00 2. "DM_ENDINTR34             ,end interrupt  this field indicates that the current descriptor finished successfully and that <end interrupt enable> in the dma command registers 0-31 is set.   0 = no interrupt  1 = interrupt was caused due to successful completion of the current transaction and <length of the transfer in bytes> field in dma command registers 0-31 = 0" "0,1"
        bitfld.long 0x00 1. "         DM_STARTINTR35   ,start interrupt  this field indicates that the current descriptor was loaded successfully and that <startirqen> in the dma command registers 0-31 is set.   0 = no interrupt  1 = interrupt was caused due to successful descriptor fetch" "0,1"
        bitfld.long 0x00 0. "   DM_BUSERRINTR36  ,bus error interrupt  this field indicates that an error occurred during a data transfer on the internal bus. the error may be due to a bad descriptor source or target address (any address that is in the non-burstable or reserved space can cause a bus error on the system bus). only one error per channel is logged. the channel that caused the error is not updated at the end of the transfer and is not accessible until it is reprogrammed and the corresponding <run> field is set.  0 = no interrupt  1 = interrupt was caused by bus error" "0,1"

group d:0xD40000A0++0x03
    line.long 0x00 "DMA_ALGN,DMA Alignment Register"
        hexmask.long.word 0x00 0.--15. 1. " DM_DALGNX53              ,alignment control for channel x  0 = source and target addresses of channel x are default aligned (internal peripherals default to 4 byte alignment, external bus addresses default to 8 byte alignment)  1 = source and target addresses of channel x are as defined by user (byte aligned)"

group d:0xD40000A4++0x03
    line.long 0x00 "DMA_PCSR,DMA Programmed I/O Control Status Register"
        bitfld.long 0x00 31. " DM_BRGSPLIT71            ,activate posted writes and split reads  0 = de-activate posted writes, split responses, split completions and retries.  activate posted writes, split responses, split completions and retries." "0,1"
        bitfld.long 0x00 0. "         DM_BRGBUSY74     ,bridge busy status  0 = no pending pio transactions across peripheral bus. a new pio transaction is not retried in this case.  1 = pending pio transaction across peripheral bus. any further pio transactions on the system bus are retried." "0,1"

group d:0xD40000E0++0x03
    line.long 0x00 "DMA_RQSR0,DREQ Status Register 0"
        bitfld.long 0x00 8. " DM_CLR88                 ,clearing pending request  writing 0x1 to this field clears the <request pending> field and thereby clears all pending requests made by the external dma request pin dreq. writing 0x0 to this field has no effect. this field can be used for clearing the requests if the channel mapped to dreq was prematurely stopped by software. this field must be set only after the mapped channel has stopped (<stop interrupt> field in the dma channel control/status registers 0-15 is set). clearing the requests of a running channel results in unpredictable behavior.  0 = no effect on <request pending>  1 = clear all pending requests registered in <request pending>" "0,1"
        bitfld.long 0x00 0.--4. "         DM_REQPEND90     ,request pending  indicates the number of pending requests on dreq." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD40000F0++0x03
    line.long 0x00 "DMA_INT,DMA Interrupt Register"
        hexmask.long.word 0x00 0.--15. 1. " DM_CHLINTRX105           ,channel interrupt  this field indicates that dma channel x has been interrupted.  0 = no interrupt  1 = interrupt"

group d:0xD4000100++0x03
    line.long 0x00 "DMA_RCMRx,DMA Request to Channel Map Registers 0-51"
        bitfld.long 0x00 7. " DM_MAPVLD115             ,map valid channel  defines whether the request is mapped to a valid channel. if the field is set, the request is mapped to a valid channel indicated by <channel number>. if the field is cleared, the request is unmapped.  this bit can also be used to mask the request.  0 = request is unmapped  1 = request is mapped to a valid channel indicated by <channel number>" "0,1"
        bitfld.long 0x00 0.--4. "         DM_CHLNUM117     ,channel number  indicates the valid channel number if <map valid channel> is set. do not map two active requests to the same channel since it produces unpredictable results." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD4000200++0x03
    line.long 0x00 "DMA_DADRx,DMA Descriptor Address Registers 0-15"
        hexmask.long 0x00 4.--31. 1. " DM_DESCRIPTOR_ADDRESS132 ,descriptor address  contains address of next descriptor."
        bitfld.long 0x00 1. "  DM_BREN134       ,enable descriptor branch  works with the <descriptor compare status> field in the dma channel control/status registers 0-31 to determine which descriptor is fetched next. if both this field and <descriptor compare status> are set, the dmac fetches the next descriptor from (ddadrx + 32 bytes). if either of the bits is cleared, dmac fetches the next descriptor from the dma descriptor address registers.  this field is relevant only for descriptor-fetch transactions (<no-descriptor fetch> field in the dma channel control/status registers 0-31 = 0).  see dreq timing requirements figure for details about the operational flow.  0 = disable descriptor branching. fetch the next descriptor from register ddadrx.  1 = enable descriptor branching" "0,1"
        bitfld.long 0x00 0. "   DM_STOP135       ,stop  if this field is cleared, a new descriptor fetch based on dma descriptor address registers and other control information is initiated after the current descriptor is completely processed.  0 = run channel  1 = stop channel after completely processing this descriptor and before fetching the next descriptor (<length of the transfer in bytes> field in dma command registers 0-31 = 0)" "0,1"

group d:0xD4000204++0x03
    line.long 0x00 "DMA_SADRx,DMA Source Address Registers 0-15"
        hexmask.long 0x00 3.--31. 1. " DM_SRCADDR152            ,source address  source address of the on-chip peripheral, external peripheral, companion chip, or address of a memory location"
        bitfld.long 0x00 2. "  DM_SRCADDR2153   ,srcaddr[2] if <source address> is a memory location and alignment register is configured. see dma alignment register for programming details and restrictions.  srcaddr[2] if <source address> is an on-chip peripheral.  reserved for all companion-chip or external peripheral-related transfers.  reserved for special dma modes, such as compare modes." "0,1"
        bitfld.long 0x00 0.--1. "   DM_SRCADDR0154   ,srcaddr[1:0] if <source address> is a memory location and alignment register is configured. see dma alignment register for programming details and restrictions.  reserved if <source address> is an on-chip peripheral.  reserved for all companion-chip or external peripheral related transfers.  reserved for special dma modes, such as compare modes." "0,1,2,3"

group d:0xD4000208++0x03
    line.long 0x00 "DMA_TADRx,DMA Target Address Registers 0-15"
        hexmask.long 0x00 3.--31. 1. " DM_TRGADDR171            ,target address  target address of the on-chip peripheral, external peripheral, companion chip, or address of a memory location"
        bitfld.long 0x00 2. "  DM_TRGADDR2172   ,trgaddr[2] if <target address> is a memory location and alignment register is configured. see dma alignment register for programming details and restrictions.  trgaddr[2] if <target address> is an on-chip peripheral.  reserved for all companion-chip or external peripheral-related transfers.  reserved for special dma modes, such as compare modes." "0,1"
        bitfld.long 0x00 0.--1. "   DM_TRGADDR0173   ,trgaddr[1:0], if target address is a memory location and alignment register is configured. see dma alignment register for programming details and restrictions.  reserved if target address is an on-chip peripheral.  reserved for all companion-chip or external peripheral related transfers.  reserved for special dma modes, such as compare modes." "0,1,2,3"

group d:0xD400020C++0x03
    line.long 0x00 "DMA_CMDx,DMA Command Registers 0-15"
        bitfld.long 0x00 31. " DM_INCSRCADDR187         ,source address increment  if the source address is an internal peripheral fifo address or external i/o address, the address is not incremented on each successive access. in these cases, this field must be cleared.  0 = do not increment source address  1 = increment source address" "0,1"
        bitfld.long 0x00 30. "         DM_INCTRGADDR188 ,target address increment  if the target address is an internal peripheral fifo address or external i/o address, the address is not incremented on each successive accesses. in these cases, this field must be cleared.  0 = do not increment target address  1 = increment target address" "0,1"
        bitfld.long 0x00 29. "   DM_FLOWSRC189    ,source flow control  the flow control of the source bit must be set if the source is an on-chip peripheral or external companion chip.  setting both this field and <target flow control> causes unpredictable behavior.  0 = do not wait for request signals associated with this channel  1 = wait for a request signal before initiating the data transfer" "0,1"
        bitfld.long 0x00 28. "     DM_FLOWTRG190  ,target flow control  the flow control of the target bit must be set if the target is an on-chip peripheral or external companion chip.  setting both the <source flow control> and this field causes unpredictable behavior.  0 = do not wait for request signals associated with this channel  1 = wait for a request signal before initiating the data transfer" "0,1"
        textline "                          "
        bitfld.long 0x00 25. "DM_CMPEN192              ,descriptor compare enable  this field must be cleared for normal dma operations.  setting the field enables the descriptor-compare mode, in which the dmac treats the current descriptor as a special case and compares data that corresponds to the source and target fields.   <addrmode> is used to determine the addressing mode before the compare operation.  0 = dma does not perform any address-compare operations  1 = dma recognizes the current descriptor as a special case and compares data based on the source address and target address fields. if the compare is true, the channel's <descriptor compare status> field in the dma channel control/status registers 0-31 is set. if the compare is false, <descriptor compare status> is cleared." "0,1"
        bitfld.long 0x00 23. "         DM_ADDRMODE194   ,addressing mode  this field controls the addressing mode for descriptor comparison and is valid only in the descriptor compare mode (<descriptor compare enable> = 1).  reserved if <descriptor compare enable> = 0.  if <descriptor compare enable> is set, the bits specify the addressing modes of the source address and target address fields. if either field contains an address, the dmac fetches the data at that address and uses it for the compare operation.  0 = source address field contains address, and target address field contains address  1 = source address field contains address, and target address field contains data  if dalgnx is clear, then the lowest three bits of immediate data are forced to be 0 before comparison. if dalgnx is set, then the lowest three bits of immediate data are not forced to be 0 before comparison." "0,1"
        bitfld.long 0x00 22. "   DM_STARTIRQEN195 ,start interrupt enable  this field indicates that the interrupt is enabled as soon as the descriptor is loaded.   in no-descriptor-fetch transfers, this field is reserved.  0 = interrupt not triggered after descriptor is loaded  1 = set interrupt bit for that channel in the <channel interrupt> field in the dma interrupt register when the descriptor (4 words) for the channel is loaded" "0,1"
        bitfld.long 0x00 21. "     DM_ENDIRQEN196 ,end interrupt enable  0 = interrupt is not triggered when length decrements to zero.  1 = set the dint interrupt bit for the channel when length decrements to zero." "0,1"
        textline "                          "
        bitfld.long 0x00 16.--18. "DM_SIZE198               ,maximum burst size  maximum burst size of each data transfer  0x0 = reserved  0x1 = 8 bytes  0x2 = 16 bytes  0x3 = 32 bytes  0x4 = 64 bytes  the size must be less than or equal to the serviced peripheral fifo trigger threshold to properly handle the respective fifo trailing bytes." "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 14.--15. "         DM_WIDTH199      ,width of the on-chip peripheral  this field is reserved for operations that do not involve on-chip peripherals, such as memory-to-memory moves and companion-chip-related operations.  width must be 0x0 for memory-to-memory moves or companion-chip-related operations.  0x0 = reserved for on-chip peripheral-related transactions  0x1 = 1 byte  0x2 = half-word (2 bytes)  0x3 = word (4 bytes)" "0,1,2,3"
        hexmask.long.word 0x00 0.--12. 1. "   DM_LEN201        ,length of the transfer in bytes  this field is the length of transfer in bytes. len = 0 means zero bytes for descriptor-fetch transactions. len = 0 is an invalid setting for no-descriptor-fetch transactions. programming len = 0 in the descriptor-fetch mode when <descriptor compare enable> is clear (normal data transfer mode) causes the channel to immediately discard the descriptor after it is fetched from memory. if the descriptor chain has more descriptors, the channel fetches the next valid descriptor. the channel stops if the descriptor chain has no more descriptors. the maximum transfer length is (8k-1) bytes.  if the transfer is of the memory-to-memory type, the length of the transfer may be any value (except for the len = 0 restriction in no-descriptor-fetch mode) up to a maximum of (8k -1) bytes. if the transfer involves an external peripheral (or a companion chip), then the length of the transfer must be an integer multiple of the peripheral fifo threshold (or water-mark).  if the transfer involves any of the on-chip peripherals, the length of the transfer must be as follows:"

group d:0xD4000300++0x03
    line.long 0x00 "DMA_DADR_Hx,DMA Descriptor Address Higher Bits Registers 0-15"
        hexmask.long.byte 0x00 0.--7. 1. " DESCRIPTOR_ADDRESS_H     ,descriptor address higher bits [39:32]. contains address of next descriptor higher bits [39:32]"

group d:0xD4000304++0x03
    line.long 0x00 "DMA_SADR_Hx,DMA Source Address Higher Bits Registers 0-15"
        hexmask.long.byte 0x00 0.--7. 1. " SOURCE_ADDRESS_H         ,source address higher bits source address higher bits[39:32] contains address of source higher bits[39:32]."

group d:0xD4000308++0x03
    line.long 0x00 "DMA_TADR_Hx,DMA Target Address Higher Bits Registers 0-15"
        hexmask.long.byte 0x00 0.--7. 1. " TARGET_ADDRESS_H         ,target address higher bits target address higher bits[39:32] contains address of target higher bits[39:32]."

group d:0xD4000000++0x03
    line.long 0x00 "DUMMY_REGISTER,This is a Dummy Register"
        hexmask.long 0x00 0.--31. 1. " DM_DUMMY250              ,this is a dummy register used as a workaround to fix an issue with the rev 2.21 perl script that requires another register follow the last include file (shown above). ignore this register as it will not show up in documentation anyway. (mclark)"

tree.end

tree "ipc"

width 10.

group d:0xD401D000++0x03
    line.long 0x00 "IPC_DW,Dummy Write Register"
        hexmask.long 0x00 0.--31. 1. " APB_IPC_DW   ,some ipc register need an dummy write operation before an read operation."

group d:0xD401D004++0x03
    line.long 0x00 "IPC_WDR,Write Data Register"
        hexmask.long 0x00 0.--31. 1. " APB_IPC_WDR  ,write data  includes a 32-bit control word to be transferred to the other side (that will be polling it). the content of this word is defined by application."

group d:0xD401D008++0x03
    line.long 0x00 "IPC_ISRW,Interrupt Set Register Write"
        hexmask.long.word 0x00 0.--15. 1. " APB_IPC_ISRW ,interrupt set  this register allows setting four different interrupts in the other side's interrupt controller.  an interrupt can be set by writing 1 to the corresponding interrupt bit in this register, as described below:"

group d:0xD401D00C++0x03
    line.long 0x00 "IPC_ICR,Interrupt Clear Register"
        hexmask.long.word 0x00 0.--15. 1. " APB_IPC_ICR  ,interrupt clear  this register is used to clear an interrupt which was asserted by the other side, by writing 1 to the corresponding interrupt bit in this register (no need to write 0 after 1)."

group d:0xD401D010++0x03
    line.long 0x00 "IPC_IIR,Interrupt Identification Register"
        hexmask.long.word 0x00 0.--15. 1. " APB_IPC_IIR  ,interrupt identification  this register is used to read the interrupt source received from the other side. if the ipc was identified as the interrupt source, one may read the interrupt identification register and identify which one of the 11 possible ipc interrupts was asserted.   note that when [10:8] were the only bits to be asserted, reading the interrupt identification register is redundant, since there is a one-to-one mapping between the interrupt source and interrupt representation on the interrupt identification register. however, when the received interrupt is <q>data_ack</q> interrupt, one must read the interrupt identification register in order to identify the interrupt cause.  note that before reading this register, one must perform a <q>dummy</q> write operation (to ipc_dw register) that latches the data to the read register. without performing the <q>write before read</q> operation, data will not be updated and old data will be read."

group d:0xD401D014++0x03
    line.long 0x00 "IPC_RDR,Read Data Register"
        hexmask.long 0x00 0.--31. 1. " APB_IPC_RDR  ,read data  this register is used to poll the write data register of the other side.   note that before reading this register, one must perform a <q>dummy</q> write operation (to ipc_dw register) that latches the data to the read register. without performing the <q>write before read</q> operation, data will not be updated and old data will be read."

tree.end

tree "tsen"

width 16.

group d:0xD4013300++0x03
    line.long 0x00 "TSEN_PCTRL,TSEN PIN Control Register"
        bitfld.long 0x00 22. " TEMP_DATA_OUTPUT_MODE ,0: result with coefficient multiply; 1: result is original adc output." "0,1"
        bitfld.long 0x00 15.--17. "     VTEST_SEL2     ,second time input voltage (0.5v ~1.2v) control.  generate different internal voltage for adc self-test; no use for normal operation mode." "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 12.--14. "     VTEST_SEL1  ,first time input voltage (0.5v ~1.2v) control.  generate different internal voltage for adc self-test; no use for normal operation mode." "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 7. "   TSEN_RAW_SEL ,sd-adc dither control 1:en_dither 0:enn_dither default:1" "0,1"
        textline "                          "
        bitfld.long 0x00 4.--6. "BJT_SEL               ,000-default internal bjt, otherwise, external bjt" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "     TSEN_ISO_EN    ,dvdd and avdd18 domain isolation enable bit.   ‘0’: normal operation  ‘1’: isolate dvdd and avdd18 power domain" "0,1"
        bitfld.long 0x00 3. "     TEMP_MODE   ,0-single test, 1-consecutive test" "0,1"
        bitfld.long 0x00 1.--2. "   INPUT_SEL    ,selectsd-adc input: 00：sensor input  01：short input 10:part of vref 11:outchip input" "0,1,2,3"
        textline "                          "
        bitfld.long 0x00 0. "EN_SENSOR             ,sensor power up 1:power-up 0:power-down" "0,1"

group d:0xD4013304++0x03
    line.long 0x00 "TSEN_INT_CLR,TSEN INTERRUPT CLEAR Register"
        bitfld.long 0x00 0. " TSEN_INT_CLR          ,interrupt clear. write 1 to clear interrupt" "0,1"

group d:0xD4013308++0x03
    line.long 0x00 "TSEN_INT_MASK,TSEN INTERRUPT MASK Register"
        bitfld.long 0x00 0. " TSEN_INT_MASK         ,interrupt clear. write 1 to mask interrupt" "0,1"

group d:0xD4013314++0x03
    line.long 0x00 "TSEN_READ_DATA,TSEN READ DATA Register"
        hexmask.long.word 0x00 16.--31. 1. " TSE_46                ,"
        hexmask.long.word 0x00 0.--15. 1. "  TSEN_READ_DATA ,tsensor result"

group d:0xD4013318++0x03
    line.long 0x00 "TSEN_TIME_CTRL,TSEN TIME CONTROL Register"
        hexmask.long.byte 0x00 24.--31. 1. " TSE_54                ,"
        hexmask.long.word 0x00 8.--23. 1. "    FILTER_PERIOD  ,filter sample period.  based on 4mhz clk cycle"
        bitfld.long 0x00 4.--7. "  RST_ADC_CNT ,reset wait time" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "  WAIT_REF_CNT ,reset reference time" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

tree.end

tree "twsi"

width 17.

group d:0xD4011000++0x03
    line.long 0x00 "TWSI_CR,Standard TWSI Register"
        bitfld.long 0x00 31. " RXOV_IE       ,receive fifo overrun interrupt enable  0 = receive fifo overrun (isr[rxov]) interrupt is not enabled  1 = receive fifo overrun (isr[rxov]) interrupt is enabled" "0,1"
        bitfld.long 0x00 30. "         RXF_IE         ,receive fifo full interrupt enable  0 = receive fifo full (isr[rxf]) interrupt is not enabled  1 = receive fifo full (isr[rxf]) interrupt is enabled" "0,1"
        bitfld.long 0x00 29. "     RXHF_IE           ,receive fifo half full interrupt enable  0 = receive fifo half full (isr[rxhf]) interrupt is not enabled  1 = receive fifo half full (isr[rxhf]) interrupt is enabled" "0,1"
        bitfld.long 0x00 28. "     TXE_IE         ,transmit fifo empty interrupt enable  0 = transmit fifo empty (isr[txe]) interrupt is not enabled  1 = transmit fifo empty (isr[txe]) interrupt is enabled" "0,1"
        textline "                           "
        bitfld.long 0x00 27. "TXDONE_IE     ,transaction done interrupt enable  0 = transaction done (isr[txd]) interrupt is not enabled.  1 = transaction done (isr[txd]) interrupt is enabled." "0,1"
        bitfld.long 0x00 26. "         MSDE           ,master stop detected enable:  0 = master stop detect (isr[msd]) status is not enabled.  1 = master stop detect (isr[msd]) status is enabled." "0,1"
        bitfld.long 0x00 25. "     MSDIE             ,master stop detected interrupt enable:  0 = disable interrupt.  1 = enables the twsi unit to interrupt the <var product number> upon detecting a master stop sent by the twsi unit." "0,1"
        bitfld.long 0x00 24. "     SSDIE          ,slave stop detected interrupt enable:  0 = disable interrupt.  1 = enables the twsi to interrupt the <var product number> when it detects a stop condition while in slave mode." "0,1"
        textline "                           "
        bitfld.long 0x00 23. "SADIE         ,slave address detected interrupt enable:  0 = disable interrupt.  1 = enables the twsi to interrupt the <var product number> upon detecting a slave address match or a general call address." "0,1"
        bitfld.long 0x00 22. "         BEIE           ,bus error interrupt enable:  0 = disable interrupt.  1 = enables the twsi to interrupt the <var product number> for the following twsi bus errors:" "0,1"
        bitfld.long 0x00 21. "     GCD               ,general call disable:  0 = enable the twsi to respond to general call messages.  1 = disable twsi response to general call messages as a slave.  this bit must be set when sending a master mode general call message from the twsi." "0,1"
        bitfld.long 0x00 20. "     DRFIE          ,dbr receive full interrupt enable:  0 = disable interrupt.  1 = enables the twsi to interrupt the <var product number> when the idbr has received a data byte from the twsi bus." "0,1"
        textline "                           "
        bitfld.long 0x00 19. "ITEIE         ,idbr transmit empty interrupt enable:  0 = disable interrupt.  1 = enables the twsi to interrupt the <var product number> after transmitting a byte onto the twsi bus." "0,1"
        bitfld.long 0x00 18. "         ALDIE          ,arbitration loss detected interrupt enable:  0 = disable interrupt.  1 = enables the twsi to interrupt the <var product number> upon losing arbitration while in master mode." "0,1"
        bitfld.long 0x00 15.--17. "     TWSI0_41          ,reserved" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 14. "     IUE            ,twsi unit enable:  0 = disables the unit and does not master any transactions or respond to any slave transactions.  1 = enables the twsi (defaults to slave-receive mode).  software must guarantee the twsi bus is idle before setting this bit.  software must guarantee that the internal clock to the twsi unit is enabled (d0cken_b[4] must be set) before setting or clearing this bit." "0,1"
        textline "                           "
        bitfld.long 0x00 13. "SCLE          ,scl enable:  0 = disables the twsi from driving the scl line.  1 = enables the twsi clock output for master-mode operation." "0,1"
        bitfld.long 0x00 12. "         MA             ,master abort:  used by the twsi in master mode to generate a stop without transmitting another data byte:  0 = the twsi transmits stop on if icr[stop] is set.  1 = the twsi sends stop without data transmission.  when in master-transmit mode, after transmitting a data byte, the icr[tb] bit is cleared and idbr[ite] bit is set. when no more data bytes need to be sent, setting master abort bit sends the stop. the icr[tb] bit must remain clear.  in master-receive mode, when a nak is sent without a stop (icr[stop] bit was not set) and the <var product number> does not send a repeated start, setting this bit sends the stop. once again, the icr[tb] bit must remain clear." "0,1"
        bitfld.long 0x00 11. "     I2C_BUS_RESET_REQ ,the twsi will do bus reset upon this bit set.this bit is self-cleared" "0,1"
        bitfld.long 0x00 10. "     UR             ,unit reset:  0 = no reset.  1 = reset the twsi only." "0,1"
        textline "                           "
        bitfld.long 0x00 8.--9. "MODE          ,bus mode (master operation):  0:0 up to 100 kbps operation - standard-mode  0:1 up to 400 kbps operation - fast-mode  1:0up to 3.4 mbps slave operation slave and up to 3.3 mbps master operation - hs-mode, standard mode when not doing a high speed transfer  1:1up to 3.4 mbps slave operation and up to 3.3 mbps master operation - hs-mode, fast mode when not doing a high speed transfer  bus mode (slave operation):  0:xhs-mode is disabled. twsi unit uses standard/fast mode timing on the sda pin.  1:xhs-mode is enabled. twsi unit uses hs-mode timing on the sda pin when a master code is received." "0,1,2,3"
        bitfld.long 0x00 7. "         TWSI0_DMA_EN49 ,dma enable for both tx and rx fifos  0 = dma mode is not enabled  1 = dma mode enabled" "0,1"
        bitfld.long 0x00 6. "     GPIOEN            ,gpio mode enable for scl during hs mode.  0 = gpio mode is not enabled and so we have open collector output for scl.  1 = gpio mode is enabled and so scl output is directly driven by twsi." "0,1"
        bitfld.long 0x00 5. "     FIFOEN         ,fifo mode  0 = fifo mode is not enabled and so we idbr has to be used to write and read data  1 = fifo mode is enabled and so fifos can be used." "0,1"
        textline "                           "
        bitfld.long 0x00 4. "TXBEGIN       ,transaction begin. set this for a new transaction only after isr[txdone] is set  0 = no transaction starting  1 = a new transaction begins  this is cleared by the hardware at the end of each transaction after a stop bit is sent out. the s/w has to set it again to start a new transaction." "0,1"
        bitfld.long 0x00 3. "         TWSI0_TB55     ,transfer byte:  used to send or receive a byte on the twsi bus:  0 = cleared by twsi when the byte is sent/received.  1 = send/receive a byte.   the <var product number> can monitor this bit to determine when the byte transfer has completed. in master or slave mode, after each byte transfer including acknowledge pulse, the twsi holds the scl line low (inserting wait states) until tb is set." "0,1"
        bitfld.long 0x00 2. "     ACKNAK56          ,the positive/negative acknowledge control bit, acknak, defines the type of acknowledge pulse sent by the twsi when in master receive mode:  0 = send a positive acknowledge (ack) pulse after receiving a data byte.  1 = send a negative acknowledge (nak) pulse after receiving a data byte.  the twsi automatically sends an ack pulse when responding to its slave address or when responding in slave-receive mode, regardless of the acknak control-bit setting." "0,1"
        bitfld.long 0x00 1. "     TWSI0_STOP57   ,stop:  used to initiate a stop condition after transferring the next data byte on the twsi bus when in master mode. in master-receive mode, the acknak control bit must be set in conjunction with the stop bit. see section 12.4.3.3, stop condition for details of the stop state.  0 = do not send a stop.  1 = send a stop." "0,1"
        textline "                           "
        bitfld.long 0x00 0. "START         ,start:  used to initiate a start condition to the twsi unit when in master mode. see section 12.4.3.1, start condition for details of the start state.  0 = do not send a start pulse.  1 = send a start pulse." "0,1"

group d:0xD4011004++0x03
    line.long 0x00 "TWSI_SR,TWSI Status Register"
        bitfld.long 0x00 31. " RXOV          ,receive fifo overrun (used in fifo mode)  0 = transmit fifo not overrun  1 = transmit fifo overrun happened" "0,1"
        bitfld.long 0x00 30. "         RXF            ,receive fifo full (used in fifo mode)  0 = receive fifo in not full  1 = receive fifo is full" "0,1"
        bitfld.long 0x00 29. "     RXHF              ,receive fifo half full (used in fifo mode)  0 = receive fifo in not half full  1 = receive fifo is half full" "0,1"
        bitfld.long 0x00 28. "     TWSI0_TXE77    ,transmit fifo empty (used in fifo mode)  0 = transmit fifo is not empty  1 = transmit fifo is empty" "0,1"
        textline "                           "
        bitfld.long 0x00 27. "TXDONE        ,transaction done (used in fifo mode)  0 = transaction is not done.   1 = transaction is done" "0,1"
        bitfld.long 0x00 26. "         MSD            ,master stop detected:  0 = no master stop detected.  1 = this bit is set by the twsi unit when all of the following are true:" "0,1"
        bitfld.long 0x00 25. "     TWSI0_83          ,reserved" "0,1"
        bitfld.long 0x00 24. "     SSD            ,slave stop detected:  0 = no stop detected.  1 = set when the twsi detects a stop while in slave-receive or slave-transmit mode." "0,1"
        textline "                           "
        bitfld.long 0x00 23. "SAD           ,slave address detected:  0 = no slave address was detected.  1 = the twsi detected a seven-bit address that matches the general call address or isar. an interrupt is signalled when enabled in the icr." "0,1"
        bitfld.long 0x00 22. "         BED            ,bus error detected:  0 = no error detected.  1 = the twsi sets this bit when it detects one of the following error conditions:  as a master transmitter, no ack was detected on the interface after a byte was sent.  as a slave receiver, the twsi generates a nak pulse." "0,1"
        bitfld.long 0x00 21. "     GCAD              ,general call address detected:  0 = no general call address received.  1 = twsi received a general call address." "0,1"
        bitfld.long 0x00 20. "     IRF            ,idbr receive full:  0 = the idbr has not received a new data byte or the twsi is idle.  1 = the idbr register received a new data byte from the twsi bus. an interrupt is signalled when enabled in the icr." "0,1"
        textline "                           "
        bitfld.long 0x00 19. "ITE           ,idbr transmit empty:  0 = the data byte is still being transmitted.  1 = the twsi has finished transmitting a data byte on the twsi bus. an interrupt is signalled when enabled in the icr." "0,1"
        bitfld.long 0x00 18. "         ALD            ,arbitration loss detected:  used during multi-master operation:  0 = cleared when arbitration is won or never took place.  1 = set when the twsi loses arbitration." "0,1"
        bitfld.long 0x00 17. "     EBB               ,early bus busy  0 = twsi bus is idle or the twsi is using the bus (that is, unit busy).  1 = set when the unit detects that the scl or sda line is low without a start condition. bit will remain set until the twsi unit detects the bus is idle by detecting a stop condition. bit will also be set whenever the ibb bit is set." "0,1"
        bitfld.long 0x00 16. "     IBB            ,twsi bus busy:  0 = twsi bus is idle or the twsi is using the bus (that is, unit busy).  1 = set when the twsi bus is busy but the <var product number> twsi is not involved in the transaction." "0,1"
        textline "                           "
        bitfld.long 0x00 15. "UB            ,unit busy:  0 = twsi not busy.  1 = set when the <var product number> twsi is busy. this is defined as the time between the first start and stop." "0,1"
        bitfld.long 0x00 14. "         ACKNAK95       ,ack/nack status:  0 = the twsi received or sent an ack on the bus.   1 = the twsi received or sent a nak.on the bus.  this bit is used in slave-transmit mode to determine when the byte transferred is the last one. this bit is updated after each byte and ack/nak information is received." "0,1"
        bitfld.long 0x00 13. "     RWM               ,read/write mode:  0 = the twsi is in master-transmit or slave-receive mode.   1 = the twsi is in master-receive or slave-transmit mode.   this is the r/nw bit of the slave address. it is cleared automatically by hardware after a stop state." "0,1"
        hexmask.long.word 0x00 0.--12. 1. "     TWSI0_97       ,reserved"

group d:0xD4011008++0x03
    line.long 0x00 "TWSI_SAR,TWSI Slave Address Register"
        hexmask.long 0x00 7.--31. 1. " TWSI0_106     ,reserved"
        hexmask.long.byte 0x00 0.--6. 1. "  SLAVE_ADDRESS  ,the seven-bit address to which the twsi responds when in slave-receive mode"

group d:0xD401100C++0x03
    line.long 0x00 "TWSI_DBR,TWSI Data Buffer Register"
        hexmask.long.tbyte 0x00 8.--31. 1. " TWSI0_118     ,reserved"
        hexmask.long.byte 0x00 0.--7. 1. "    DATA_BUFFER    ,buffer for twsi bus send/receive data."

group d:0xD4011010++0x03
    line.long 0x00 "TWSI_LCR,TWSI Load Count Register"
        bitfld.long 0x00 27.--31. " HLVL          ,decrementer load value for high speed mode scl (master mode) for low phase. the twsi in master mode will generate an scl to support up to 1.8 mbps data rate with the reset value." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        hexmask.long.word 0x00 18.--26. 1. "        HLVH           ,decrementer load value for high speed mode scl (master mode) for high phase. the twsi in master mode will generate an scl to support up to 1.8 mbps data rate with the reset value."
        hexmask.long.word 0x00 9.--17. 1. "  FLV               ,decrementer load value for fast mode scl (master mode) for both high and low phase.   twsi in master mode generates an scl to support up to 400 kbps data rate with the reset value."
        hexmask.long.word 0x00 0.--8. 1. "  SLV            ,decrementer load value for standard mode scl (master mode) for both high & low phase.   twsi in master mode generates an scl to support up to 100 kbps data rate with the reset value."

group d:0xD4011014++0x03
    line.long 0x00 "TWSI_WCR,TWSI Wait Count Register"
        hexmask.long.tbyte 0x00 15.--31. 1. " TWSI0_142     ,reserved"
        bitfld.long 0x00 10.--14. "    HS_COUNT2      ,count value for defining high speed mode stop bit setup and hold times.  default: decimal 5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 5.--9. "    HS_COUNT1         ,count value for defining high speed mode start bit setup and hold times.  default: decimal 1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 0.--4. "    TWSI0_COUNT147 ,controls the counter values defining the setup and hold times in standard and fast mode  recommended values:  01010 => 33 mhz twsi functional clock  10100 => 66 mhz twsi functional clock  default: decimal 26" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD4011018++0x03
    line.long 0x00 "TWSI_RST_CYC,TWSI Bus reset cycle counter"
        bitfld.long 0x00 0.--3. " RST_CYC       ,the cycles of scl during bus reset" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD401101C++0x03
    line.long 0x00 "TWSI_BMR,TWSI Bus Monitor Register"
        hexmask.long 0x00 2.--31. 1. " TWSI0_168     ,reserved"
        bitfld.long 0x00 1. "  SCL            ,ibmr[scl] continuously reflects the value of the scl pin." "0,1"
        bitfld.long 0x00 0. "     TWSI0_SDA170      ,ibmr[sda] continuously reflects the value of the sda pin." "0,1"

group d:0xD4011020++0x03
    line.long 0x00 "TWSI_WFIFO,TWSI Write FIFO Register"
        hexmask.long.tbyte 0x00 12.--31. 1. " TWSI0_179     ,reserved"
        bitfld.long 0x00 8.--11. "    CONTROL        ,twsi bus send/receive data control bits. these control bits are essentially icr[3:0] bits." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.byte 0x00 0.--7. 1. "    TWSI0_DATA181     ,twsi bus send data for write transactions and dummy data for read transactions"

group d:0xD4011024++0x03
    line.long 0x00 "TWSI_WFIFO_WPTR,TWSI Write FIFO Write Pointer Register"
        hexmask.long 0x00 4.--31. 1. " TWSI0_189     ,reserved"
        bitfld.long 0x00 0.--3. "  TWSI0_DATA190  ,this is the location in the tx fifo where the next entry will be written to by the software." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4011028++0x03
    line.long 0x00 "TWSI_WFIFO_RPTR,TWSI Write FIFO Read Pointer Register"
        hexmask.long 0x00 4.--31. 1. " TWSI0_198     ,reserved"
        bitfld.long 0x00 0.--3. "  TWSI0_DATA199  ,this is the location in the tx fifo where the next entry will be read from by the hardware." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD401102C++0x03
    line.long 0x00 "TWSI_RFIFO,TWSI Read FIFO Register"
        hexmask.long.byte 0x00 0.--7. 1. " TWSI0_DATA208 ,twsi bus receive data for read transactions."

group d:0xD4011030++0x03
    line.long 0x00 "TWSI_RFIFO_WPTR,TWSI Read FIFO Write Pointer Register"
        bitfld.long 0x00 0.--4. " TWSI0_DATA217 ,this is the location in the rx fifo where the next entry will be written to by the hardware." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD4011034++0x03
    line.long 0x00 "TWSI_RFIFO_RPTR,TWSI Read FIFO Read Pointer Register"
        bitfld.long 0x00 0.--4. " TWSI0_DATA226 ,this is the location in the rx fifo where the next entry will be read from by the software." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

tree.end

tree "usb_otg"

width 28.

group d:0xD4208000++0x03
    line.long 0x00 "USB_ID,Identification Register"
        bitfld.long 0x00 29.--31. " CIVERSION         ,identifies the ci version" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 25.--28. "         VERSION          ,identifies the core version" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 21.--24. "    US_REVISION26    ,revision number of the core" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--20. "  TAG              ,identifies the tag of core" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                      "
        hexmask.long.byte 0x00 8.--15. 1. "NID               ,ones complement version of id"
        hexmask.long.byte 0x00 0.--5. 1. "        US_ID30          ,configuration number  this number is set to 0x05 and indicates that the peripheral is the usb-hs usb 2.0 core."

group d:0xD4208004++0x03
    line.long 0x00 "USB_HWGENERAL,General Hardware Parameters Register"
        bitfld.long 0x00 10.--11. " US_SM38           ,reserved for internal testing" "0,1,2,3"
        bitfld.long 0x00 6.--9. "         US_PHYM39        ,reserved for internal testing" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--5. "    US_PHYW40        ,reserved for internal testing" "0,1,2,3"
        bitfld.long 0x00 3. "   US_BWT41         ,reserved for internal testing" "0,1"
        textline "                                      "
        bitfld.long 0x00 1.--2. "US_CLKC42         ,reserved for internal testing" "0,1,2,3"
        bitfld.long 0x00 0. "         US_RT43          ,reserved for internal testing" "0,1"

group d:0xD4208008++0x03
    line.long 0x00 "USB_HWHOST,Host Hardware Parameters Register"
        hexmask.long.byte 0x00 24.--31. 1. " US_TTPER50        ,reserved for internal testing"
        hexmask.long.byte 0x00 16.--23. 1. "        US_TTASY51       ,reserved for internal testing"
        bitfld.long 0x00 1.--3. "    US_NPORT53       ,reserved for internal testing" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0. "   US_HC54          ,reserved for internal testing" "0,1"

group d:0xD420800C++0x03
    line.long 0x00 "USB_HWDEVICE,Device Hardware Parameters Register"
        bitfld.long 0x00 1.--5. " US_DEVEP62        ,reserved for internal testing" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 0. "        US_DC63          ,device capable  reserved for internal testing" "0,1"

group d:0xD4208010++0x03
    line.long 0x00 "USB_HWTXBUF,TX Buffer Hardware Parameters Register"
        bitfld.long 0x00 31. " US_TXLCR70        ,reserved for internal testing" "0,1"
        hexmask.long.byte 0x00 16.--23. 1. "         US_TXCHANADD72   ,reserved for internal testing"
        hexmask.long.byte 0x00 8.--15. 1. "    US_TXADD73       ,reserved for internal testing"
        hexmask.long.byte 0x00 0.--7. 1. "  US_TCBURST74     ,reserved for internal testing"

group d:0xD4208014++0x03
    line.long 0x00 "USB_HWRXBUF,RX Buffer Hardware Parameters Register"
        hexmask.long.byte 0x00 8.--15. 1. " US_RXADD82        ,reserved for internal testing"
        hexmask.long.byte 0x00 0.--7. 1. "        US_RXBURST83     ,reserved for internal testing"

group d:0xD4208018++0x03
    line.long 0x00 "USB_HWRXBUF,RX Buffer Hardware Parameters Register"
        bitfld.long 0x00 28.--31. " EP7_TXFIFO_SIZE   ,to define tx fifo size for endpoint7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "        EP6_TXFIFO_SIZE  ,to define tx fifo size for endpoint6" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "    EP5_TXFIFO_SIZE  ,to define tx fifo size for endpoint5" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "  EP4_TXFIFO_SIZE  ,to define tx fifo size for endpoint4" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                      "
        bitfld.long 0x00 12.--15. "EP3_TXFIFO_SIZE   ,to define tx fifo size for endpoint3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "        EP2_TXFIFO_SIZE  ,to define tx fifo size for endpoint2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "    EP1_TXFIFO_SIZE  ,to define tx fifo size for endpoint1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "  EP0_TXFIFO_SIZE  ,to define tx fifo size for endpoint0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD420801C++0x03
    line.long 0x00 "USB_HWRXBUF,RX Buffer Hardware Parameters Register"
        bitfld.long 0x00 28.--31. " EP15_TXFIFO_SIZE  ,to define tx fifo size for endpoint15" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "        EP14_TXFIFO_SIZE ,to define tx fifo size for endpoint14" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "    EP13_TXFIFO_SIZE ,to define tx fifo size for endpoint13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "  EP12_TXFIFO_SIZE ,to define tx fifo size for endpoint12" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                      "
        bitfld.long 0x00 12.--15. "EP11_TXFIFO_SIZE  ,to define tx fifo size for endpoint11" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "        EP10_TXFIFO_SIZE ,to define tx fifo size for endpoint10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "    EP9_TXFIFO_SIZE  ,to define tx fifo size for endpoint9" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "  EP8_TXFIFO_SIZE  ,to define tx fifo size for endpoint8" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4208080++0x03
    line.long 0x00 "GPTIMER0LD,Device/Host Timer Registers"
        hexmask.long.tbyte 0x00 0.--23. 1. " GPTLD             ,this field is the value to be loaded into the gptcnt countdown timer on a reset action. the value in this register represents the time in microseconds minus 1 for the timer duration."

group d:0xD4208084++0x03
    line.long 0x00 "GPTIMER0CTRL,"
        bitfld.long 0x00 31. " GTPRUN            ,this bit enables the general-purpose timer to run. setting or clearing this bit will not have an effect on the gptcnt counter value." "0,1"
        bitfld.long 0x00 30. "         GPTRST           ,writing a one to this bit will reload the gptcnt with the value in gptld." "0,1"
        bitfld.long 0x00 24. "     GPTMODE          ,0b' – one shot; '1b' – repeat. this bit selects between a single timer countdown and a looped countdown. in one-shot mode, the timer will count down to zero, generate an interrupt and stop until the counter is reset by software. in repeat mode, the timer will count down to zero, generate an interrupt and automatically reload the counter to begin again." "0,1"
        hexmask.long.tbyte 0x00 0.--23. 1. "   GPTCNT           ,this field is the value of the running timer."

group d:0xD4208088++0x03
    line.long 0x00 "GPTIMER1LD,"
        hexmask.long.byte 0x00 0.--7. 1. " US_CAPLENGTH150   ,caplength"

group d:0xD4208102++0x03
    line.long 0x00 "USB_HCIVERSION,Host Interface Version Number - EHCI Compliant Register"
        hexmask.long.word 0x00 0.--15. 1. " US_HCIVERSION157  ,hciversion"

group d:0xD4208104++0x03
    line.long 0x00 "USB_HCSPARAMS,Host Ctrl. Structural Parameters EHCI Compliant with"
        bitfld.long 0x00 24.--27. " US_N_TT165        ,number of transaction translators (n_tt)  this field indicates the number of embedded transaction translators associated with the usb2.0 host controller.  this in a non-ehci field to support embedded tt." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "        US_N_PTT166      ,number of ports per transaction translator (n_ptt)  this field indicates the number of ports assigned to each transaction translator within the usb2.0 host controller.  this in a non-ehci field to support embedded tt." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16. "    US_PI168         ,port indicators (p indicator)  this bit indicates whether the ports support port indicator control.  1 = port status and control registers include a read/writeable field for controlling the state of the port indicator  this field will always be 1." "0,1"
        bitfld.long 0x00 12.--15. "   US_N_CC169       ,number of companion controller (n_cc)  this field indicates the number of companion controllers associated with this usb2.0 host controller.  0 = there are no internal companion controllers. port-ownership hand-off is not supported.  in this implementation, this field will always be 0." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                      "
        bitfld.long 0x00 8.--11. "US_N_PCC170       ,number of ports per companion controller  this field indicates the number of ports supported per internal companion controller. it is used to indicate the port routing configuration to the system software.  the number in this field must be consistent with <n_ports[3:0]> and <n_cc[3:0]>." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4. "        US_PPC172        ,port power control  this field indicates whether the host controller implementation includes port power control.  0 = ports do not have port power switches  the value of this field affects the functionality of the port power field in each port status and control register." "0,1"
        bitfld.long 0x00 0.--3. "     US_N_PORTS173    ,number of downstream ports  this field specifies the number of physical downstream ports implemented on this host controller." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4208108++0x03
    line.long 0x00 "USB_HCCPARAMS,Host Ctrl. Capability Parameters EHCI Compliant"
        hexmask.long.byte 0x00 8.--15. 1. " US_EECP181        ,ehci extended capabilities pointer  this optional field indicates the existence of a capabilities list.  0x00 = no extended capabilities are implemented"
        bitfld.long 0x00 4.--7. "        US_IST182        ,isochronous scheduling threshold  this field indicates, relative to the current position of the executing host controller, where software can reliably update the isochronous schedule. when bit [7] is zero, the value of the least significant 3 bits indicates the number of micro-frames a host controller can hold a set of isochronous data structures (one or more) before flushing the state.  this field will always be 0." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 2. "    US_ASP184        ,asynchronous schedule park capability  1 = the host controller supports the park feature for high-speed queue heads in the asynchronous schedule. the feature can be disabled or enabled and set to a specific level by using the <asynchronous schedule park mode enable> and <asp[1:0]> fields in the usb command register.  this field will always be 1." "0,1"
        bitfld.long 0x00 1. "   US_PFL185        ,programmable frame list flag  1 = system software can specify and use a smaller frame list and configure the host controller via the <fs[1:0]> field in the usb command register. the frame list must always be aligned on a 4k-page boundary. this requirement ensures that the frame list is always physically contiguous.  this field will always be 1." "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "US_ADC186         ,64-bit addressing capability  this field will always be 0. no 64-bit addressing capability is supported." "0,1"

group d:0xD4208120++0x03
    line.long 0x00 "USB_DCIVERSION,Dev. Interface Version Number Register"
        hexmask.long.word 0x00 0.--15. 1. " US_DCIVERSION194  ,dciversion"

group d:0xD4208124++0x03
    line.long 0x00 "USB_DCCPARAMS,Device Ctrl. Capability Parameters Register"
        bitfld.long 0x00 8. " US_HC202          ,host capable  1 = this controller is capable of operating as an ehci compatible usb 2.0 host controller" "0,1"
        bitfld.long 0x00 7. "         US_DC203         ,device capable  1 = this controller is capable of operating as a usb 2.0 device" "0,1"
        bitfld.long 0x00 0.--4. "     US_DEN205        ,device endpoint number  this field indicates the number of endpoints built into the device controller. if this controller is not device capable, then this field will be 0. valid values are 0 to 16." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD4208140++0x03
    line.long 0x00 "USB_CMD,USB Command Register"
        hexmask.long.byte 0x00 16.--23. 1. " US_ITC217         ,interrupt threshold control  the system software uses this field to set the maximum rate at which the host/device controller will issue interrupts. this field contains the maximum interrupt interval measured in micro-frames. valid values are provided below.  value maximum interrupt interval:  0x00 = immediate (no threshold)  0x01 = 1 micro-frame  0x02 = 2 micro-frames  0x04 = 4 micro-frames  0x08 = 8 micro-frames  0x10 = 16 micro-frames  0x20 = 32 micro-frames  0x40 = 64 micro-frames"
        bitfld.long 0x00 1. "        US_RST219        ,controller reset (reset)  software uses this field to reset the controller. it is set to 0 by the host/device controller when the reset process is complete. software cannot terminate the reset process early by writing 0 to this register.  host controller: when software writes 1 to this bit, the host controller resets its internal pipelines, timers, counters, state machines etc. to their initial value. any transaction currently in progress on usb is immediately terminated. a usb reset is not driven on downstream ports. software should not set this bit to 1 when the <hchaited> field in the usb status register is a zero. attempting to reset an actively running host controller will result in undefined behavior.  device controller: when software writes 1 to this bit, the device controller resets its internal pipelines, timers, counters, state machines etc. to their initial value. writing 1 to this bit when the device is in the attached state is not recommended, since the effect on an attached host is undefined. in order to ensure that the device is not in an attached state before initiating a device controller reset, all primed endpoints should be flushed and the <run/stop> field in the usb command register should be set to 0." "0,1"
        bitfld.long 0x00 0. "     US_RS220         ,run/stop (rs)  0 = stop  1 = run  host controller: when set to 1, the host controller proceeds with the execution of the schedule. the host controller continues execution as long as this bit is set to a 1. when this bit is set to 0, the host controller completes the current transaction on the usb and then halts. the <hchaited> field in the usb status register indicates when the host controller has finished the transaction and has entered the stopped state. software should not write a 1 to this field unless the host controller is in the halted state (when <hchaited> = 1).  device controller: writing 1 to this field will cause the device controller to enable a pull-up on d+ and initiate an attach event. this control bit is not directly connected to the pull-up enable, as the pull-up will become disabled upon transitional into high-speed mode. software should use this field to prevent an attach event before the device controller has been properly initialized. writing 0 to this will cause a detach event." "0,1"

group d:0xD4208144++0x03
    line.long 0x00 "USB_STS,USB Status Register"
        bitfld.long 0x00 25. " US_TI1228         ,this bit is set when the counter in the gptimer1ctrl register transitions to zero. writing a one to this bit will clear it." "0,1"
        bitfld.long 0x00 24. "         TI2              ,this bit is set when the counter in the gptimer2ctrl register transitions to zero. writing a one to this bit will clear it." "0,1"
        bitfld.long 0x00 19. "     US_UPI231        ,this bit is set by the host controller when the cause of an interrupt is a completion of a usb transaction where the transfer descriptor (td) has an interrupt on complete (ioc) bit set and the td was from the periodic schedule. this bit is also set by the host controller when a short packet is detected and the packet is on the periodic schedule. a short packet is when the actual number of bytes received was less than expected. this bit is not used by the device controller and will always be zero." "0,1"
        bitfld.long 0x00 18. "   US_UAI232        ,this bit is set by the host controller when the cause of an interrupt is a completion of a usb transaction where the transfer descriptor (td) has an interrupt on complete (ioc) bit set and the td was from the asynchronous schedule. this bit is also set by the host when a short packet is detected and the packet is on the asynchronous schedule. a short packet is when the actual number of bytes received was less than expected. this bit is not used by the device controller and will always be zero." "0,1"
        textline "                                      "
        bitfld.long 0x00 16. "US_NAKI234        ,this bit is read-only. it is set by hardware when for a particular endpoint both the tx/rx" "0,1"
        bitfld.long 0x00 10. "         US_ULPII236      ,ulpi interrupt  when the ulpi viewport is present in the design, an event completion will set this interrupt.  this is used by both host and device controller. only present in designs where configuration constant vusb_hs_phy_ulpi = 1." "0,1"
        bitfld.long 0x00 8. "     US_SLI238        ,dcsuspend  when a device controller enters a suspend state from an active state, this bit will be set to 1. the device controller clears the bit upon exiting from a suspend state." "0,1"
        bitfld.long 0x00 7. "   US_SRI239        ,sof received  0 = default. when the device controller detects a start of (micro) frame, this field will be set to 1. when a sof is extremely late, the device controller will automatically set this bit to indicate that an sof was expected. therefore, this field will be set roughly every 1 ms in device fs mode and every 125 ms in hs mode and will be synchronized to the actual sof that is received.  since the device controller is initialized to fs before connect, this field will be set at an interval of 1 ms during the prelude to connect and chirp.  in host mode, this bit will be set every 125 <mu>s and can be used by the host controller driver as a time base.  software writes 1 to this bit to clear it.  this is a non-ehci status bit." "0,1"
        textline "                                      "
        bitfld.long 0x00 6. "US_URI240         ,usb reset received  when the device controller detects a usb reset and enters the default state, this bit will be set to 1. software can write 1 to this field to clear the usb reset received status bit." "0,1"
        bitfld.long 0x00 5. "         AAI_0B_08H       ,interrupt on async advance  system software can force the host controller to issue an interrupt the next time the host controller advances the asynchronous schedule by writing 1 to the <interrupt on async advance doorbell> field in the usb command register. this status bit indicates the assertion of that interrupt source." "0,1"
        bitfld.long 0x00 4. "     US_SEI242        ,in the bvci implementation of the usbhs core, this bit is not used, and will always be cleared to '0b'. in the amba implementation, this bit will be set to '1b' when an error response is seen by the master interface (hresp[1:0]=error)." "0,1"
        bitfld.long 0x00 3. "   US_FRI243        ,frame list rollover  the host controller sets this field to 1 when the frame list index rolls over from its maximum value to 0. the exact value at which the rollover occurs depends on the frame list size. for example. if the frame list size (as programmed in the <fs[1:0]> field in the usb command register) is 1024, the usb frame index register rolls over every time frindex[13] toggles. similarly, if the size is 512, the host controller sets this bit to a one every time fhindex[12] toggles." "0,1"
        textline "                                      "
        bitfld.long 0x00 2. "US_PCI244         ,port change detect  the host controller sets this bit to 1 when on any port a connect status occurs, a port enable/disable change occurs, or the <force port resume> field in the port status/control register is set as the result of a j-k transition on the suspended port.  the device controller sets this bit to 1 when the port controller enters the full or high-speed operational state.  when the port controller exits the full or high-speed operation states due to reset or suspend events, the notification mechanisms are the <iaa> field in the usb command register and the <dcsuspend> bits respectively.  this bit is not ehci compatible." "0,1"
        bitfld.long 0x00 1. "         US_UEI245        ,usb error interrupt (usberrint)  when completion of a usb transaction results in an error condition, this field is set by the host/device controller. this field is set along with the <ui>, if the td on which the error interrupt occurred also had its interrupt on complete (ioc) bit set.  the device controller detects resume signaling only." "0,1"
        bitfld.long 0x00 0. "     US_UI246         ,usb interrupt (usbint)  this field is set by the host/device controller when the cause of an interrupt is a completion of a usb transaction where the transfer descriptor (td) has an interrupt on complete (ioc) bit set.  this bit is also set by the host/device controller when a short packet is detected. a short packet is when the actual number of bytes received was less than the expected number of bytes." "0,1"

group d:0xD4208148++0x03
    line.long 0x00 "USB_INTR,USB Interrupt Enable Register"
        bitfld.long 0x00 25. " US_TIE1254        ,when this bit is a one, and the ti1 bit in the extsts register is a one, the controller will issue an interrupt. the interrupt is acknowledged by software clearing the ti1 bit." "0,1"
        bitfld.long 0x00 24. "         US_TIE0255       ,when this bit is a one, and the ti0 bit in the extsts register is a one, the controller will issue an interrupt. the interrupt is acknowledged by software clearing the ti0 bit." "0,1"
        bitfld.long 0x00 19. "     US_UPEI257       ,when this bit is a one, and the upi bit in the extsts register is a one, the host controller will issue an interrupt at the next interrupt threshold. the interrupt is acknowledged by software clearing the upi bit." "0,1"
        bitfld.long 0x00 18. "   US_UAEI258       ,when this bit is a one, and the uai bit in the extsts register is a one, the host controller will issue an interrupt at the next interrupt threshold. the interrupt is acknowledged by software clearing the uai bit." "0,1"
        textline "                                      "
        bitfld.long 0x00 16. "US_NAKE260        ,nak interrupt enable  this bit is set by software if it wants to enable the hardware interrupt for the <nak interrupt bit> field in the usb status register. if both this bit and the corresponding <nak interrupt bit> field are set, a hardware interrupt is generated." "0,1"
        bitfld.long 0x00 10. "         US_ULPIE262      ,when this bit is a one, and the ulpi interrupt bit in the usbsts register transitions, the controller will issue and interrupt. the interrupt is acknowledged by software writing a one to the ulpi interrupt bit." "0,1"
        bitfld.long 0x00 8. "     US_SLE264        ,sleep enable  when this bit is 1, and the <dcsuspend> field in the usb status register transitions, the device controller will issue an interrupt. the interrupt is acknowledged by software writing 1 to the <dcsuspend> field.  only used by the device controller." "0,1"
        bitfld.long 0x00 7. "   US_SRE265        ,sof received enable  when this bit is 1, and the <sof received> field in the usb status register is 1, the device controller will issue an interrupt. the interrupt is acknowledged by software clearing the <sof received> field." "0,1"
        textline "                                      "
        bitfld.long 0x00 6. "US_URE266         ,usb reset enable  when this bit is 1, and the <usb reset received> field in the usb status register is 1, the device controller will issue an interrupt. the interrupt is acknowledged by software clearing the <usb reset received> field.  only used by the device controller." "0,1"
        bitfld.long 0x00 5. "         US_AAE267        ,interrupt on async advance enable  when this bit is 1, and the <aai 0b-08h> field in the usb status register is 1, the host controller will issue an interrupt at the next interrupt threshold. the interrupt is acknowledged by software clearing the <aai 0b-08h> field.  only used by the host controller." "0,1"
        bitfld.long 0x00 4. "     US_SEE268        ,system error enable  when this bit is 1, and bit 4 in the usb status register is 1, the host/device controller will issue an interrupt. the interrupt is acknowledged by software clearing bit 4 in the usb status register." "0,1"
        bitfld.long 0x00 3. "   US_FRE269        ,frame list rollover enable  when this bit is 1, and the <frame list rollover> field in the usb status register is 1, the host controller will issue an interrupt. the interrupt is acknowledged by software clearing the <frame list rollover> field.  only used by the host controller." "0,1"
        textline "                                      "
        bitfld.long 0x00 2. "US_PCE270         ,port change detect enable  when this bit is 1, and the <port change detect> field in the usb status register is 1, the host/device controller will issue an interrupt. the interrupt is acknowledged by software clearing the <port change detect> field." "0,1"
        bitfld.long 0x00 1. "         US_UEE271        ,usb error interrupt enable  when this bit is 1, and the <usb error interrupt (usberrint)> field in the usb status register is 1, the host controller will issue an interrupt at the next interrupt threshold. the interrupt is acknowledged by software clearing the <usb error interrupt (usberrint)> field." "0,1"
        bitfld.long 0x00 0. "     US_UE272         ,usb interrupt enable  when this bit is 1 and the <usb interrupt (usbint)> field in the usb status register is 1, the host/device controller will issue an interrupt at the next interrupt threshold. the interrupt is acknowledged by software clearing the <usb interrupt (usbint)> field." "0,1"

group d:0xD420814C++0x03
    line.long 0x00 "USB_FRINDEX,USB Frame Index Register"
        hexmask.long.word 0x00 0.--13. 1. " US_FRINDEX280     ,frame index  the value in this register increments at the end of each time frame (e.g. micro-frame). bits [n:3] are used for the frame list current index. this means that each location of the frame list is accessed 8 times (frames or micro-frames) before moving to the next index.  the following illustrates values of n based on the value of the <fs[1:0]> field in the usb command register, when used in host mode.  usbcmd [frame list size] number elements n  0x0 (1024) = 12  0x1 (512) = 11  0x2 (256) = 10  0x3 (128) = 9  0x4 (64) = 8  0x5 (32) = 7  0x6 (16) = 6  0x7 (8) = 5  in device mode, the value is the current frame number of the last frame transmitted. it is not used as an index.  in either mode, bits 2:0 indicate the current microframe."

group d:0xD4208154++0x03
    line.long 0x00 "USB_PERIODICLISTBASE,Host Controller Frame List Base Address Register (Host Mode)"
        hexmask.long.tbyte 0x00 12.--31. 1. " US_BASEADR287     ,base address (low)  these bits correspond to memory address signals [31:12], respectively. only used by the host controller."

group d:0xD4208154++0x03
    line.long 0x00 "USB_DEVICEADDR,Device Controller USB Device Address Register (Device Mode)"
        hexmask.long.byte 0x00 25.--31. 1. " USBADR            ,device address  these bits correspond to the usb device address"
        bitfld.long 0x00 24. "        USBADRA          ,device address advance  0 = any writes to <device address> are instantaneous  1 = at the same time or before <device address> is written, the write to the device address field is staged and held in a hidden register. after an in occurs on endpoint 0 and is acked, device address will be loaded from the holding register.  hardware will automatically clear this bit on the following conditions:" "0,1"

group d:0xD4208158++0x03
    line.long 0x00 "USB_ASYNCLISTADDR,Host Controller Next Asynchronous List Address Register"
        hexmask.long 0x00 5.--31. 1. " US_ASYBASE308     ,link pointer low (lpl)  these bits correspond to memory address signals [31:5], respectively. this field may only reference a queue head (oh). only used by the host controller."

group d:0xD4208158++0x03
    line.long 0x00 "USB_ENDPOINTLISTADDR,Address at Endpoint List in Memory Register"
        hexmask.long.tbyte 0x00 11.--31. 1. " EPBASE            ,endpoint list pointer (low)  these bits correspond to memory address signals [31:11], respectively. this field will reference a list of up to 32 qhs. (that is, one queue head per endpoint and direction.)"

group d:0xD4208160++0x03
    line.long 0x00 "USB_BURSTSIZE,Programmable Burst Size Register - Host Controller"
        hexmask.long.word 0x00 8.--16. 1. " US_TXPBURST325    ,programmable tx burst length  this register represents the maximum length of a the burst in 32-bit words while moving data from system memory to the usb bus."
        hexmask.long.byte 0x00 0.--7. 1. "      US_RXPBURST326   ,programmable rx burst length  this register represents the maximum length of a the burst in 32-bit words while moving data from the usb bus to system memory."

group d:0xD4208178++0x03
    line.long 0x00 "USB_ENDPTNAK,Endpoint NAK Register"
        hexmask.long.word 0x00 16.--31. 1. " US_EPTN334        ,tx endpoint nak  each tx endpoint has 1 bit in this field. the bit is set when the device sends a nak handshake on a received in token for the corresponding endpoint.  bit 3 – endpoint #3  bit 2 – endpoint #2  bit 1 – endpoint #1  bit 0 – endpoint #0  all other bits are reserved."
        hexmask.long.word 0x00 0.--15. 1. "      US_EPRN335       ,rx endpoint nak  each rx endpoint has 1 bit in this field. the bit is set when the device sends a nak handshake on a received out or ping token for the corresponding endpoint.  bit 3 – endpoint #3  bit 2 – endpoint #2  bit 1 – endpoint #1  bit 0 – endpoint #0  all other bits are reserved."

group d:0xD420817C++0x03
    line.long 0x00 "USB_ENDPTNAKEN,Endpoint NAK Enable Register"
        hexmask.long.word 0x00 16.--31. 1. " US_EPTNE342       ,tx endpoint nak enable  each bit is an enable bit for the corresponding <eptn [15:0]> field in the endptnak. if this bit is set and the corresponding <eptn [15:0]> bit is set, the <nak interrupt bit> field in the usb status register is set.  bit 3 – endpoint #3  bit 2 – endpoint #2  bit 1 – endpoint #1  bit 0 – endpoint #0  all other bits are reserved."
        hexmask.long.word 0x00 0.--15. 1. "      US_EPRNE343      ,rx endpoint nak enable  each bit is an enable bit for the corresponding <eprn [15:0]> field in the endptnak. if this bit is set and the corresponding <eprn [15:0]> bit is set, the <nak interrupt bit> field in the usb status register is set.  bit 3 – endpoint #3  bit 2 – endpoint #2  bit 1 – endpoint #1  bit 0 – endpoint #0  all other bits are reserved."

group d:0xD4208184++0x03
    line.long 0x00 "USB_PORTSC,Port Status/Control Register"
        bitfld.long 0x00 30.--31. " US_PTS350         ,parallel transceiver select  utmi/utmi+  this bit is not defined in the ehci specification." "0,1,2,3"
        bitfld.long 0x00 29. "         US_STS351        ,this register bit is used in conjunction with the configuration constant vusb_hs_phy_serial to control whether the parallel or serial transceiver interface is selected for fs and ls operation. the serial interface engine can be used in combination with the utmi+ physical interface to provide fs/ls signaling instead of the parallel interface. if vusb_hs_phy_serial is set for 0 or 1 then this bit is read only. if vusb_hs_phy_serial is 2 or 3 then this bit is read/write. this bit has no effect unless parallel transceiver select is set to utmi+. the serial/1.1 and ic_usb physical interface will use the serial interface engine for fs/ls signaling regardless of this bit value." "0,1"
        bitfld.long 0x00 28. "     US_PTW352        ,parallel transceiver width  8-bit [60 mhz] utmi  this bit is not defined in the ehci specification." "0,1"
        bitfld.long 0x00 26.--27. "   US_PSPD353       ,port speed  this register field indicates the speed at which the port is operating. for hs mode operation in the host controller and hs/fs operation in the device controller, the port routing steers data to the protocol engine. for fs and ls mode operation in the host controller, the port routing steers data to the protocol engine w/ embedded transaction translator.  0x0 = full speed  0x1 = low speed  0x2 = high speed  this bit is not defined in the ehci specification." "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 25. "US_PTS2354        ,parallel transceiver select – rw. default = implementation dependent. msb bit of pts field." "0,1"
        bitfld.long 0x00 24. "         US_PFSC355       ,port force full speed connect  writing this bit to 1 will force the port to only connect at full speed. it disables the chirp sequence that allows the port to identify itself as high speed. this is useful for testing fs configurations with a hs host, hub, or device.  this field is not defined in the ehci specification.  this field is for debugging purposes." "0,1"
        bitfld.long 0x00 23. "     US_PHCD356       ,phy low power suspend - clock disable (plpscd)  0 = enables the phy clock  1 = disables the phy clock  reading this field will indicate the status of the phy clock.  the phy clock cannot be disabled if it is being used as the system clock.  in device mode, the phy can be put into low power suspend clock disable when the device is not running (<run/stop> field in the usb command register = 0) or the host has signaled suspend (<suspend> field in the port status/control register = 1). low power suspend will be cleared automatically when the host has signaled resume. before forcing a resume from the device, the device controller driver must clear this field.  in host mode, the phy can be put into low power suspend clock disable when the downstream device has been put into suspend mode or when no downstream device is connected. low power suspend is completely under the control of software.  this field is not defined in the ehci specification." "0,1"
        bitfld.long 0x00 22. "   US_WKOC357       ,wake on disconnect enable (wkdscnnt_e)  writing this bit to 1 enables the port to be sensitive to device disconnects as wake-up events.  this field is 0 if <port power> field in the port status/control register is 0 or in device mode.  this bit is output from the controller as signal pwrctl_wake_dscnnt_en (otg/host core only) for use by an external power control circuit." "0,1"
        textline "                                      "
        bitfld.long 0x00 21. "WKDC              ,wake on disconnect enable (wkdscnnt_e)  writing this bit to 1 enables the port to be sensitive to device disconnects as wake-up events.  this field is 0 if <port power> field in the port status/control register is 0 or in device mode.  this bit is output from the controller as signal pwrctl_wake_dscnnt_en (otg/host core only) for use by an external power control circuit." "0,1"
        bitfld.long 0x00 20. "         US_WKCN359       ,wake on connect enable (wkcnnt_e)  writing this field to 1 enables the port to be sensitive to device connects as wake-up events.  this field is 0 if <port power> field in the port status/control (portsc) register is zero or in device mode.  this bit is output from the controller as signal pwrctl_wake_dscnnt_en (otg/host core only) for use by an external power control circuit." "0,1"
        bitfld.long 0x00 16.--19. "     US_PTC360        ,port test control  any other value than 0 indicates that the port is operating in test mode.  0x0 = test_mode_disable  0x1 = j_ state  0x2 = k_state  0x3 = se0 (host) / nak (device)  0x4 = packet  0x5 = force_enable_hs  0x6 = force_enable_fs  0x7 = force_enable_ls  0x8 to 0xf = reserved  the force_enable_fs and force enable_ls are extensions to the test mode support specified in the ehci specification. writing this field to any of the force_enable_{hs/fs/ls} values will force the port into the connected and enabled state at the selected speed. writing this field back to test_mode_disable will allow the port state machines to progress normally from that point.  low speed operations are not supported as a peripheral device." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 14.--15. "  US_PIC361        ,port indicator control  writing to this field has no effect if the <port indicators (p indicator)> field in the host ctrl. structural parameters (hcsparams) ehci compliant with extensions register is 0. if <port indicators (p indicator)> is 1, then the bit is:  0x0 = port indicators are off  0x1 = amber  0x2 = green  0x3 = undefined  refer to the usb specification revision 2.0 [3] for a description on how these bits are to be used.  this field is output from the controller as signals port_ind_ctl_1 and port_ind_ctl_0 for use by an external led driving circuit." "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 13. "US_PO362          ,port owner hand off is not implemented in this design, therefore this bit will always read back as 0b." "0,1"
        bitfld.long 0x00 12. "         US_PP363         ,port power (pp)  the function of this field depends on the value of the <ppc> field in the host ctrl. structural parameters ehci compliant with extensions register. the behavior is as follows:  <ppc> pp operation  0 0 ro — a device controller with no otg capability does not have port power control switches.  1 1/0 – rw. host/otg controller requires port power control switches. this field represents the current setting of the switch (0 = off, 1 = on). when power is not available on a port (that is, this field equals 0), the port is non-functional and will not report attaches, detaches, etc.  when an over-current condition is detected on a powered port and <ppc> is 1, the bit in each affected port may be transitioned by the host controller driver from 1 to 0 (removing power from the port).  this feature is implemented in the host/otg controller (<ppc> = 1).  in a device only implementation, port power control is not necessary, thus <ppc> and this field = 0." "0,1"
        bitfld.long 0x00 10.--11. "     US_LS364         ,line status  this field reflects the current logical levels of the d+ (bit 11) and d- (bit 10) signal lines. the encoding of the bits are:  0x0 = se0  0x2 = j-state  0x1 = k-state  0x3 = undefined  in host mode, the use of linestate by the host controller driver is not necessary (unlike ehci) because the port controller state machine and the port routing manage the connection of ls and fs.  in device mode, the use of linestate by the device controller driver is not necessary." "0,1,2,3"
        bitfld.long 0x00 9. "   US_HSP365        ,high-speed port  0 = host/device connected to the port is not in a high-speed mode  1 = host/device connected to the port is in high-speed mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "US_PR368          ,port reset  this field is 0 if <port power> is 0.  in host mode:  0 = port is not in reset  1 = port is in reset  when software writes 1 to this field, the bus-reset sequence as defined in the usb specification revision 2.0 is started. this field will automatically change to 0 after the reset sequence is complete. this behavior is different from ehci where the host controller driver is required to set this bit to 0 after the reset duration is timed in the driver.  in device mode: this bit is a read only status bit. device reset from the usb bus is also indicated in the usb status register." "0,1"
        bitfld.long 0x00 7. "         US_SUSP369       ,suspend  in host mode:  0 = port not in suspend state  1 = port in suspend state    the <pe> field in the port status/control register and suspend bit of this register define the port states as follows:  0x = disable  10 = enable  11 = suspend  when in suspend state, downstream propagation of data is blocked on this port, except for port reset. the blocking occurs at the end of the current transaction if a transaction was in progress when this bit was written to 1. in the suspend state, the port is sensitive to resume detection. note that the bit status does not change until the port is suspended and that there may be a delay in suspending a port if there is a transaction currently in progress on the usb.  the host controller will unconditionally set this bit to zero when software sets the <fpr> bit to zero. the host controller ignores a write of zero to this bit.  if the host software sets this bit to a one when the port is not enabled (i.e. <pe> bit is a zero), the results are undefined.  this field is zero if <pp> is zero in host mode.    in device mode:  0 = port not in suspend state  1 = port in suspend state  in device mode, this bit is a read only status bit." "0,1"
        bitfld.long 0x00 6. "     US_FPR370        ,force port resume  0 = no resume (k-state) detected/driven on port  1 = resume detected/driven on port    in host mode: software sets this field to 1 to drive resume signaling. the host controller sets this bit to 1 if a j-to-k transition is detected while the port is in the suspend state. when this bit transitions to 1 because a j-to-k transition is detected, the <port change detect> field in the usb status register is also set to 1. this field will automatically change to 0 after the resume sequence is complete. this behavior is different from ehci where the host controller driver is required to set this bit to 0 after the resume duration is timed in the driver." "0,1"
        bitfld.long 0x00 5. "   US_OCC373        ,over-current change  1 = this field gets set to 1 when there is a change to over-current active. software clears this field by writing 1 to this bit position." "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "US_OCA374         ,over-current active  0 = this port does not have an over-current condition. this field will automatically transition from 1 to 0 when the over current condition is removed." "0,1"
        bitfld.long 0x00 3. "         US_PEC375        ,port enable/disable change  0 = no change  1 = port enabled/disabled status has changed  in host mode: for the root hub, this field gets set to 1 only when a port is disabled due to disconnect on the port or due to the appropriate conditions existing at the eof2 point (see chapter 11 of the usb specification). software clears this by writing 1 to it.   this field is 0 if <port power> is 0.  in device mode: the device port is always enabled. (this bit will be 0.)" "0,1"
        bitfld.long 0x00 2. "     US_PE376         ,port enabled/disabled  0 = disable (default)  1 = enable  in host mode: ports can only be enabled by the host controller as a part of the reset and enable. software cannot enable a port by writing 1 to this field. ports can be disabled by either a fault condition (disconnect event or other fault condition) or by the host software. note that the bit status does not change until the port state actually changes. there may be a delay in disabling or enabling a port due to other host controller and bus events.  when the port is disabled, (0) downstream propagation of data is blocked except for reset.  this field is 0 if <port power> is 0 in host mode.  in device mode: the device port is always enabled. (this bit will be 1.)" "0,1"
        bitfld.long 0x00 1. "   US_CSC377        ,connect status change  0 = no change  1 = change in current connect status  in host mode: indicates a change has occurred in the port's current connect status. the host/device controller sets this field for all changes to the port device connect status, even if system software has not cleared an existing connect status change. for example, the insertion status changes twice before system software has cleared the changed condition, hub hardware will be setting an already-set bit (that is, the bit will remain set). software clears this field by writing 1 to it.  this field is 0 if <port power> is zero in host mode.  in device mode: this bit is undefined in device controller mode." "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "US_CCS378         ,current connect status  in host mode: this value reflects the current state of the port and may not correspond directly to the event that caused the <connect status change> field to be set.  0 = no device is present  1 = device is present on port  this field is 0 if <port power> is zero in host mode.  in device mode: when set to 1, it indicates that the device successfully attached and is operating in either high speed or full speed as indicated by the <high-speed port> field. when set to 0, it indicates that the device did not attach successfully or was forcibly disconnected by the software writing 0 to the run bit in the usb command register. it does not state the device being disconnected or suspended.  0 = not attached  1 = attached" "0,1"

group d:0xD42081A4++0x03
    line.long 0x00 "USB_OTGSC,OTG Status and Control Register"
        bitfld.long 0x00 30. " DPIE              ,data pulse interrupt enable" "0,1"
        bitfld.long 0x00 29. "         1MSE             ,1 millisecond timer interrupt enable" "0,1"
        bitfld.long 0x00 28. "     BSEIE            ,b session end interrupt enable  setting this field enables the b session end interrupt." "0,1"
        bitfld.long 0x00 27. "   BSVIE            ,b session valid interrupt enable  setting this field enables the b session valid interrupt." "0,1"
        textline "                                      "
        bitfld.long 0x00 26. "ASVIE             ,a session valid interrupt enable  setting this field enables the a session valid interrupt." "0,1"
        bitfld.long 0x00 25. "         AVVIE            ,a vbus valid interrupt enable  setting this field enables the a vbus valid interrupt." "0,1"
        bitfld.long 0x00 24. "     IDIE             ,usb id interrupt enable  setting this field enables the usb id interrupt." "0,1"
        bitfld.long 0x00 22. "   DPIS             ,data pulse interrupt status  this bit is set when data bus pulsing occurs on dp or dm. data bus pulsing is only detected when the <controller mode> field in the usb device mode register = host (0x3) and the <port power> field in the port status/control register = off (0).  software must write 1 to clear this field." "0,1"
        textline "                                      "
        bitfld.long 0x00 21. "1MSS              ,1 millisecond timer interrupt status  this bit is set once every millisecond.  software must write 1 to clear this bit." "0,1"
        bitfld.long 0x00 20. "         BSEIS            ,b session end interrupt status  this bit is set when vbus has fallen below the b session end threshold.  software must write 1 to clear this bit." "0,1"
        bitfld.long 0x00 19. "     BSVIS            ,b session valid interrupt status  this bit is set when vbus has either risen above or fallen below the b session valid threshold (0.8 vdc).  software must write 1 to clear this bit." "0,1"
        bitfld.long 0x00 18. "   ASVIS            ,a session valid interrupt status  this bit is set when vbus has either risen above or fallen below the a session valid threshold (0.8 vdc).  software must write 1 to clear this bit." "0,1"
        textline "                                      "
        bitfld.long 0x00 17. "AVVIS             ,a vbus valid interrupt status  this field is set when vbus has either risen above or fallen below the vbus valid threshold (4.4 vdc) on an a device.  software must write 1 to clear this bit." "0,1"
        bitfld.long 0x00 16. "         IDIS             ,usb id interrupt status  this bit is set when a change on the id input has been detected.  software must write 1 to clear this field." "0,1"
        bitfld.long 0x00 14. "     DPS              ,data bus pulsing status  1 = data bus pulsing is being detected on the port" "0,1"
        bitfld.long 0x00 13. "   1MST             ,1 millisecond timer toggle  this field toggles once per millisecond." "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "BSE               ,b session end  indicates vbus is below the b session end threshold." "0,1"
        bitfld.long 0x00 11. "         BSV              ,b session valid  indicates vbus is above the b session valid threshold." "0,1"
        bitfld.long 0x00 10. "     ASV              ,a session valid  indicates vbus is above the a session valid threshold." "0,1"
        bitfld.long 0x00 9. "   AVV              ,a vbus valid  indicates vbus is above the a vbus valid threshold." "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "US_ID408          ,usb id  0 = a device  1 = b device" "0,1"
        bitfld.long 0x00 7. "         HABA             ,hardware assist b-disconnect to a-connect  0 = disabled  1 = enable automatic b-disconnect to a-connect sequence" "0,1"
        bitfld.long 0x00 6. "     HADP             ,hardware assist data pulse (write to set)  1 = start data pulse sequence" "0,1"
        bitfld.long 0x00 5. "   IDPU             ,id pullup  this field provides control over the id pull-up resister.  0 = off  1 = on  when this bit is 0, the id input will not be sampled." "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "DP                ,data pulsing  setting this field causes the pullup on dp to be asserted for data pulsing during srp." "0,1"
        bitfld.long 0x00 3. "         OT               ,otg termination  this field must be set when the otg device is in device mode, this controls the pulldown on dm." "0,1"
        bitfld.long 0x00 2. "     HAAR             ,hardware assist auto-reset  0 = disabled  1 = enable automatic reset after connect on host port" "0,1"
        bitfld.long 0x00 1. "   VC               ,vbus charge  setting this field causes the vbus line to be charged. this is used for vbus pulsing during srp." "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "VD                ,vbus_discharge  setting this field causes vbus to discharge through a resistor." "0,1"

group d:0xD42081A8++0x03
    line.long 0x00 "USB_MODE,USB Device Mode Register"
        bitfld.long 0x00 15. " SRT               ,when the controller is in host mode, this bit enables a bypass of the chirp j/k reset handshake, saving 6-7ms in simulation time for each reset sequence. this bit should only be used for initial system integration simulations, and should always be set to 0 for normal operation." "0,1"
        bitfld.long 0x00 5. "         VBPS             ,this bit is connected to the vbus_pwr_select output and can be used for any generic control but is named to be used by logic that selects between an on-chip vbus power source (charge pump) and an off-chip source in systems when both are available." "0,1"
        bitfld.long 0x00 4. "     US_SDIS427       ,stream disable mode  0 = inactive  1 = active  device mode: setting to a 1 disables double priming on both rx and tx for low bandwidth systems. this mode ensures that when the rx and tx buffers are sufficient to contain an entire packet, that the standard double buffering scheme is disabled to prevent overruns/underruns in bandwidth limited systems." "0,1"
        bitfld.long 0x00 3. "   US_SLOM432       ,setup lockout mode  in device mode, this field controls behavior of the setup lock mechanism. see control endpoint operation model.  0 = setup lockouts on  1 = setup lockouts off (dcd requires use of setup data buffer tripwire in the usb command register)" "0,1"
        textline "                                      "
        bitfld.long 0x00 2. "US_ES433          ,endian select  this field can change the byte ordering of the transfer buffers to match the host microprocessor bus architecture. the bit fields in the microprocessor interface and the dma data structures (including the setup buffer within the device qh) are unaffected by the value of this field because they are based upon 32-bit words.  0 = little endian – first byte referenced in least significant byte of 32-bit word  1 = big endian - first byte referenced in most significant byte of 32-bit word" "0,1"
        bitfld.long 0x00 0.--1. "         US_CM434         ,controller mode  controller mode is defaulted to the proper mode for host only and device only implementations. for those designs that contain both host and device capability, the controller will default to an idle state and will need to be initialized to the desired operating mode after reset. for combination host/device controllers, this register can only be written once after reset. if it is necessary to switch modes, software must reset the controller by writing to the <controller reset (reset)> field in the usb command register before reprogramming this register.  0x0 = idle  0x1 = reserved  0x2 = device controller  0x3 = host controller" "0,1,2,3"

group d:0xD42081AC++0x03
    line.long 0x00 "USB_ENDPTSETUPSTAT,Endpoint Setup Status Register"
        hexmask.long.word 0x00 0.--15. 1. " ENDPTSETUPSTAT150 ,setup endpoint status  for every setup transaction that is received, a corresponding bit in this register is set to 1. software must clear or acknowledge the setup transfer by writing 1 to a respective bit after it has read the setup data from queue head. the response to a setup packet as in the order of operations and total response time is crucial to limit bus time outs while the setup lock our mechanism is engaged. see managing endpoints in the device operational mode.  this register is only used in device mode."

group d:0xD42081B0++0x03
    line.long 0x00 "USB_ENDPTPRIME,Endpoint Initialization Register"
        hexmask.long.word 0x00 16.--31. 1. " PETB              ,prime endpoint transmit buffer  for each endpoint, a corresponding bit is used to request that a buffer prepared for a transmit operation in order to respond to a usb in/interrupt transaction. software should write 1 to the corresponding bit when posting a new transfer descriptor to an endpoint. hardware will automatically use this bit to begin parsing for a new transfer descriptor from the queue head and prepare a transmit buffer. hardware will clear this bit when the associated endpoint(s) is (are) successfully primed.  these bits will be momentarily set by hardware during hardware re-priming operations when a dtd is retired, and the dqh is updated.  petb[3] – endpoint #3  petb[2] – endpoint #2  petb[1] – endpoint #1  petb[0] – endpoint #0  all other bits are reserved."
        hexmask.long.word 0x00 0.--15. 1. "      PERB             ,prime endpoint receive buffer  for each endpoint, a corresponding bit is used to request a buffer prepare for a receive operation for when a usb host initiates a usb out transaction. software should write 1 to the corresponding bit whenever posting a new transfer descriptor to an endpoint. hardware will automatically use this bit to begin parsing for a new transfer descriptor from the queue head and prepare a receive buffer. hardware will clear this bit when the associated endpoint(s) is (are) successfully primed.  these bits will be momentarily set by hardware during hardware re-priming operations when a dtd is retired, and the dqh is updated.  bit 3 – endpoint #3  bit 2 – endpoint #2  bit 1 – endpoint #1  bit 0 – endpoint #0  all other bits are reserved."

group d:0xD42081B4++0x03
    line.long 0x00 "USB_ENDPTFLUSH,Endpoint De-Initialize Register"
        hexmask.long.word 0x00 16.--31. 1. " FETB              ,flush endpoint transmit buffer  writing 1 to a bit(s) in this register will cause the associated endpoint(s) to clear any primed buffers. if a packet is in progress for one of the associated endpoints, then that transfer will continue until completion. hardware will clear this register after the endpoint flush operation is successful.  fetb[3] – endpoint #3  fetb[2] – endpoint #2  fetb[1] – endpoint #1  fetb[0] – endpoint #0  all other bits are reserved."
        hexmask.long.word 0x00 0.--15. 1. "      FERB             ,flush endpoint receive buffer  writing 1 to a bit(s) will cause the associated endpoint(s) to clear any primed buffers. if a packet is in progress for one of the associated endpoints, then that transfer will continue until completion. hardware will clear this register after the endpoint flush operation is successful.  bit 3 – endpoint #3  bit 2 – endpoint #2  bit 1 – endpoint #1  bit 0 – endpoint #0  all other bits are reserved."

group d:0xD42081B8++0x03
    line.long 0x00 "USB_ENDPTSTAT,Endpoint STAT Register"
        hexmask.long.word 0x00 16.--31. 1. " ETBR              ,endpoint transmit buffer ready  one bit for each endpoint indicates status of the respective endpoint buffer. this bit is set to 1 by the hardware as a response to receiving a command from a corresponding bit in the endpoint initialization register. there will always be a delay between setting a bit in the endpoint initialization register and endpoint indicating ready. this delay time varies based upon the current usb traffic and the number of bits set in the endpoint initialization register. buffer ready is cleared by usb reset, by the usb dma system, or through the endpoint de-initialize register."
        hexmask.long.word 0x00 0.--15. 1. "      ERBR             ,endpoint receive buffer ready  one bit for each endpoint indicates status of the respective endpoint buffer. this bit is set to 1 by the hardware as a response to receiving a command from a corresponding bit in the endpoint initialization register. there will always be a delay between setting a bit in the endpoint initialization register and endpoint indicating ready. this delay time varies based upon the current usb traffic and the number of bits set in the endpoint initialization register. buffer ready is cleared by usb reset, by the usb dma system, or through the endpoint de-initialize register."

group d:0xD42081BC++0x03
    line.long 0x00 "USB_ENDPTCOMPLETE,Endpoint Complete Register"
        hexmask.long.word 0x00 16.--31. 1. " ETCE              ,endpoint transmit complete event  each bit indicates a transmit event (in/interrupt) occurred and software should read the corresponding endpoint queue to determine the endpoint status. if the corresponding ioc bit is set in the transfer descriptor, then this bit will be set simultaneously with the usbint. writing 1 will clear the corresponding bit in this register.  etce[3] – endpoint #3  etce[2] – endpoint #2  etce[1] – endpoint #1  etce[0] – endpoint #0  all other bits are reserved."
        hexmask.long.word 0x00 0.--15. 1. "      ERCE             ,endpoint receive complete event  each bit indicates a received event (out/setup) occurred and software should read the corresponding endpoint queue to determine the transfer status. if the corresponding ioc bit is set in the transfer descriptor, then this bit will be set simultaneously with the usbint. writing 1 will clear the corresponding bit in this register.  erce[3] – endpoint #3  erce[2] – endpoint #2  erce[1] – endpoint #1  erce[0] – endpoint #0  all other bits are reserved."

group d:0xD42081C0++0x03
    line.long 0x00 "USB_ENDPTCTRL0,Endpoint Control 0 Register"
        bitfld.long 0x00 23. " US_TXE486         ,tx endpoint enable  1 = enabled  endpoint0 is always enabled." "0,1"
        bitfld.long 0x00 18.--19. "         TXT488           ,tx endpoint type  0x0 = control  endpoint0 is fixed as a control end point." "0,1,2,3"
        bitfld.long 0x00 16. "     TXS490           ,tx endpoint stall  0 = end point ok  1 = end point stalled  software can write 1 to this field to force the endpoint to return a stall handshake to the host. it will continue returning stall until the field is cleared by software or it will automatically be cleared upon receipt of a new setup request." "0,1"
        bitfld.long 0x00 7. "   RXE492           ,rx endpoint enable  1 = enabled  endpoint0 is always enabled." "0,1"
        textline "                                      "
        bitfld.long 0x00 2.--3. "RXT494            ,rx endpoint type  0x0 = control  endpoint0 is fixed as a control end point." "0,1,2,3"
        bitfld.long 0x00 0. "         RXS496           ,rx endpoint stall  0 = end point ok  1 = end point stalled  software can write 1 to this field to force the endpoint to return a stall handshake to the host. it will continue returning stall until the field is cleared by software or it will automatically be cleared upon receipt of a new setup request." "0,1"

group d:0xD42081C4++0x03
    line.long 0x00 "USB_ENDPTCTRL1-ENDPTCTRL15,Endpoint Control 1 to Endpoint Control 15 Registers"
        bitfld.long 0x00 23. " US_TXE504         ,tx endpoint enable  0 = disabled  1 = enabled  an endpoint should be enabled only after it has been configured." "0,1"
        bitfld.long 0x00 22. "         TXR              ,tx data toggle reset (ws)  write 1 reset pid sequence  whenever a configuration event is received for this endpoint, software must write 1 to this field in order to synchronize the data pid's between the host and device." "0,1"
        bitfld.long 0x00 21. "     TXI              ,tx data toggle inhibit  0 = pid sequencing enabled  1 = pid sequencing disabled  this field is only used for test and should always be written as 0. writing 1 to this field will cause this endpoint to ignore the data toggle sequence and always transmit data0 for a data packet." "0,1"
        bitfld.long 0x00 18.--19. "   TXT508           ,tx endpoint type  0x0 = control  0x1 = isochronous  0x2 = bulk  0x3 = interrupt" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 17. "TXD               ,tx endpoint data source  0 = dual port memory buffer/dma engine  this field should always be written as 0." "0,1"
        bitfld.long 0x00 16. "         TXS510           ,tx endpoint stall  0 = end point ok  1 = end point stalled  this field will be set automatically upon receipt of a setup request if this endpoint is not configured as a control endpoint. it will be cleared automatically upon receipt of a setup request if this endpoint is configured as a control endpoint.  software can write 1 to this field to force the endpoint to return a stall handshake to the host. it will continue to return stall until this field is either cleared by software or automatically cleared as above." "0,1"
        bitfld.long 0x00 7. "     RXE512           ,rx endpoint enable  0 = disabled  1 = enabled  an endpoint should be enabled only after it has been configured." "0,1"
        bitfld.long 0x00 6. "   RXR              ,rx data toggle reset (ws) write  1 = reset pid sequence  whenever a configuration event is received for this endpoint, software must write 1 to this field in order to synchronize the data pid's between the host and device." "0,1"
        textline "                                      "
        bitfld.long 0x00 5. "RXI               ,rx data toggle inhibit  0 = disabled  1 = enabled  this field is only used for test and should always be written as 0. writing 1 to this field will cause this endpoint to ignore the data toggle sequence and always accept data packet regardless of their data pid." "0,1"
        bitfld.long 0x00 2.--3. "         RXT516           ,rx endpoint type  0x0 = control  0x1 = isochronous  0x2 = bulk  0x3 = reserved" "0,1,2,3"
        bitfld.long 0x00 1. "     US_RXD517        ,rx endpoint data sink tbd  0 = dual port memory buffer/dma engine  this field should always be written as 0." "0,1"
        bitfld.long 0x00 0. "   RXS518           ,rx endpoint stall  0 = end point ok  1 = end point stalled  this field will be set automatically upon receipt of a setup request if this endpoint is not configured as a control endpoint. it will be cleared automatically upon receipt a setup request if this endpoint is configured as a control endpoint.  software can write 1 to this field to force the endpoint to return a stall handshake to the host. it will continue to returning stall until this field is either cleared by software or automatically cleared as above." "0,1"

tree.end

tree "cpdma"

width 16.

group d:0xD0200000++0x03
    line.long 0x00 "DMA_CSR031,DMA Channel Control/Status Registers 0-31"
        bitfld.long 0x00 31. " DM_RUN16                 ,run  this field allows software to start or stop the channel. if it is cleared in the middle of the burst, the burst is completed before the channel stops. setting this field starts the stopped channel.  if the channel is in a descriptor-fetch transfer and this field is set before writing a valid descriptor address to the dma descriptor address registers, no-descriptor fetch occurs.  this bit is reset as soon as it is cleared and when the channel stops normally. after the channel stops, the <stop interrupt> field is set. the <stop interrupt> field must be polled to read the channel status or to set the <stop interrupt enabled> field and expect an interrupt after the channel stops.  0 = stops the channel  1 = starts the channel" "0,1"
        bitfld.long 0x00 30. "         DM_NODESCFETCH17 ,no-descriptor fetch  this bit controls whether or not a channel has a descriptor. if this field is set, the channel is considered a simple channel with no descriptors. in this case, the dma does not initiate descriptor fetches when software sets the <run> field or when the byte count for the current transfer reaches zero.  to program the channel for a no-descriptor-fetch transfer, software must set, then write to the individual dma source address registers 0-31, dma target address registers 0-31, and dma command registers 0-31 for that channel. the dma descriptor address registers are not used in this mode and must not be written. the <run> field must be set to allow the channel to start the transfer.   if this field is cleared, the dmac initiates descriptor-fetches when software writes to the dma descriptor address registers, when the byte count for the current transfer reaches zero.  0 = descriptor-fetch transfer  1 = no-descriptor-fetch transfer" "0,1"
        bitfld.long 0x00 29. "   DM_STOPIRQEN18   ,stop interrupt enabled  this field enables the interrupt when the <stop interrupt> field is set. if this field is cleared, no interrupt is generated after the channel stops.  the <stop interrupt> field is set after system reset de-assertion. thus, if <stop interrupt> is set before the channel is started, an interrupt is generated.  0 = no interrupt if the channel is in uninitialized or stopped state  1 = interrupt enabled if the channel is in uninitialized or stopped state" "0,1"
        bitfld.long 0x00 28. "     DM_EORIRQEN19  ,setting the end-of-receive interrupt enable  this field triggers an interrupt on an eor condition. clearing this bit does not generate an eor-related interrupt.  0 = interrupt not triggered even if the <end of receive interrupt> field is set  1 = enable interrupt if <end of receive interrupt> is set" "0,1"
        textline "                          "
        bitfld.long 0x00 27. "DM_EORJMPEN20            ,jump to the next descriptor on eor  this field controls the descriptor flow when the mapped peripheral signals an eor to the dmac. see descriptor behavior on end-of-receive (eor) figure for the behavior of the descriptor during this condition.  this control bit has no effect on the channel for no-descriptor-fetch transfers (<no-descriptor fetch> set). the dmac completes the peripheral-to-memory data transfer on an eor, regardless of this field.  0 = dmac continues to hold the current descriptor and waits until the mapped peripheral makes another receive request.  1 = dmac jumps to the channel's next descriptor on receiving an eor from the mapped peripheral." "0,1"
        bitfld.long 0x00 26. "         DM_EORSTOPEN21   ,stop channel on eor  this field has no effect on the channel for no-descriptor-fetch transfers (<no-descriptor fetch> set). the dmac completes the peripheral-to-memory data transfer on an eor, regardless of this field.  setting this field causes the dmac to stop the channel on an eor and set the corresponding <stop interrupt> field. if the <stop interrupt enabled> field is set when this field is set, an interrupt occurs.  see descriptor behavior on end-of-receive (eor) figure for the behavior of the descriptor.  0 = dmac continues to hold the current descriptor and waits until the mapped peripheral makes another receive request.  1 = dmac stops the channel that received an eor from the mapped peripheral." "0,1"
        bitfld.long 0x00 25. "   DM_SETCMPST22    ,set descriptor compare status  this field partially controls <descriptor compare status>. setting this bit sets <descriptor compare status>. clearing this field has no effect on <descriptor compare status>. software can set the <descriptor compare status> even if the descriptor is not configured in the compare mode (<descriptor compare enable> field in dma command registers 0-31 = 0).   0 = no effect on <descriptor compare status>  1 = set <descriptor compare status>" "0,1"
        bitfld.long 0x00 24. "     DM_CLRCMPST23  ,clear descriptor compare status  this field partially controls <descriptor compare status>. setting this field clears <descriptor compare status>. clearing this field has no effect on <descriptor compare status>. software can set <descriptor compare status> even if the descriptor is not configured in the compare mode.  0 = no effect on <descriptor compare status>  1 = clear <descriptor compare status>" "0,1"
        textline "                          "
        bitfld.long 0x00 23. "DM_RASIRQEN24            ,request after channel stopped interrupt enable  0 = interrupt not triggered when a peripheral asserts a dma request after the channel has stopped  1 = set interrupt bit for that channel in the <channel interrupt> in the dma interrupt register when a peripheral asserts a dma request after the channel has stopped." "0,1"
        bitfld.long 0x00 22. "         DM_MASKRUN25     ,mask <run> during a programmed i/o write to this register  0 = software (programmed i/o write) can modify <run> during a write transaction  1 = software (programmed i/o write) can not modify <run> during a write transaction" "0,1"
        bitfld.long 0x00 10. "   DM_CMPST27       ,descriptor compare status  this field indicates the most recent status of the source and target compare operation. it is set on a successful compare of the source and target fields. an unsuccessful comparison clears it. refer to the description of <addrmode> in the dma command registers 0-31 for the various addressing modes used for this comparison. for details regarding the descriptor compare mode, refer to <descriptor compare enable> in the dma command registers 0 to 31.  the dmac updates cmpst only in descriptor compare mode (<descriptor compare enable> = 1).  this field can be set and cleared by setting <set descriptor compare status> and <clear descriptor compare status>, respectively.  if software attempts to concurrently set and clear this field by setting both <set descriptor compare status> and <clear descriptor compare status>, <set descriptor compare status> has higher precedence. modifying this bit after <run> is set and the channel is actively running leads to faulty behavior of the descriptor chain. the channel must be stopped before setting or clearing this field.  0 = indicates an unsuccessful address compare in descriptor-compare mode.  1 = indicates a successful compare of the current descriptor source and target addresses in descriptor-compare mode." "0,1"
        bitfld.long 0x00 9. "     DM_EORINT28    ,end of receive interrupt  eorint pertains only to internal peripherals. this field indicates the status of the mapped peripheral's receive data. it is set after the dmac reads out the last trailing sample from the peripheral's receive fifo. the descriptor behavior on end-of-receive (eor) figure illustrates the behavior of the descriptor during this condition.  0 = dma continues with current descriptor because the internal peripheral is still actively receiving data  1 = channel mapped internal peripheral has no data remaining in its receive fifo and has completed all receive transactions. refer to the description of <jump to the next descriptor on eor> for the behavior of the dmac during this condition." "0,1"
        textline "                          "
        bitfld.long 0x00 8. "REQPEND30                ,request pending  this field indicates a pending request for the dma channel.  reqpend is cleared for a channel if that channel has no pending request or the request has just been issued to the memory interface in case of a read or write from the external companion chip to memory.   if dreq assertion sets reqpend and <run> is cleared to stop that channel, reqpend and the internal registers that hold the dreq assertion information, do not remain set. if the channel is restarted, reqpend must be reset by a descriptor that transfers dummy data (for example, a memory-to-memory transfer from a temporary location to another temporary location).   0 = no request is pending for the channel  1 = a request is pending for the channel" "0,1"
        bitfld.long 0x00 4. "         DM_RASINTR32     ,request after channel stopped  0 = no interrupt   1 = interrupt caused due to a request made by the peripheral after the respective channel stopped  this bit is reset by writing a 1." "0,1"
        bitfld.long 0x00 3. "   DM_STOPINTR33    ,stop interrupt  this is a read-only bit that reflects the channel state.  software must clear <stop interrupt enabled> to reset the interrupt. reprogramming the dma descriptor address registers and setting <run> restarts the channel.  0 = channel is running  1 = channel is in uninitialized or stopped state. if <stop interrupt enabled> is set, the dmac generates an interrupt." "0,1"
        bitfld.long 0x00 2. "     DM_ENDINTR34   ,end interrupt  this field indicates that the current descriptor finished successfully and that <end interrupt enable> in the dma command registers 0-31 is set.   0 = no interrupt  1 = interrupt was caused due to successful completion of the current transaction and <length of the transfer in bytes> field in dma command registers 0-31 = 0" "0,1"
        textline "                          "
        bitfld.long 0x00 1. "DM_STARTINTR35           ,start interrupt  this field indicates that the current descriptor was loaded successfully and that <startirqen> in the dma command registers 0-31 is set.   0 = no interrupt  1 = interrupt was caused due to successful descriptor fetch" "0,1"
        bitfld.long 0x00 0. "         DM_BUSERRINTR36  ,bus error interrupt  this field indicates that an error occurred during a data transfer on the internal bus. the error may be due to a bad descriptor source or target address (any address that is in the non-burstable or reserved space can cause a bus error on the system bus). only one error per channel is logged. the channel that caused the error is not updated at the end of the transfer and is not accessible until it is reprogrammed and the corresponding <run> field is set.  0 = no interrupt  1 = interrupt was caused by bus error" "0,1"

group d:0xD02000A0++0x03
    line.long 0x00 "DMA_ALGN,DMA Alignment Register"
        hexmask.long 0x00 0.--31. 1. " DM_DALGNX52              ,alignment control for channel x  0 = source and target addresses of channel x are default aligned (internal peripherals default to 4 byte alignment, external bus addresses default to 8 byte alignment)  1 = source and target addresses of channel x are as defined by user (byte aligned)"

group d:0xD02000A4++0x03
    line.long 0x00 "DMA_PCSR,DMA Programmed I/O Control Status Register"
        bitfld.long 0x00 31. " DM_BRGSPLIT70            ,activate posted writes and split reads  0 = de-activate posted writes, split responses, split completions and retries.  activate posted writes, split responses, split completions and retries." "0,1"
        bitfld.long 0x00 2. "         DPCSR_2_R        ," "0,1"
        bitfld.long 0x00 1. "   DPCSR_1_R        ," "0,1"
        bitfld.long 0x00 0. "     DM_BRGBUSY74   ,bridge busy status  0 = no pending pio transactions across peripheral bus. a new pio transaction is not retried in this case.  1 = pending pio transaction across peripheral bus. any further pio transactions on the system bus are retried." "0,1"

group d:0xD02000E0++0x03
    line.long 0x00 "DMA_RQSR0,DREQ Status Register 0"
        bitfld.long 0x00 8. " CLR88                    ,clearing pending request  writing 0x1 to this field clears the <request pending> field and thereby clears all pending requests made by the external dma request pin dreq. writing 0x0 to this field has no effect. this field can be used for clearing the requests if the channel mapped to dreq was prematurely stopped by software. this field must be set only after the mapped channel has stopped (<stop interrupt> field in the dma channel control/status registers 0-31 is set). clearing the requests of a running channel results in unpredictable behavior.  0 = no effect on <request pending>  1 = clear all pending requests registered in <request pending>" "0,1"
        bitfld.long 0x00 0.--4. "         REQPEND90        ,request pending  indicates the number of pending requests on dreq." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD02000E4++0x03
    line.long 0x00 "DMA_RQSR1,DREQ Status Register 1"
        bitfld.long 0x00 8. " CLR98                    ,clearing pending request  writing 0x1 to this field clears the <request pending> field and thereby clears all pending requests made by the external dma request pin dreq. writing 0x0 to this field has no effect. this field can be used for clearing the requests if the channel mapped to dreq was prematurely stopped by software. this field must be set only after the mapped channel has stopped (<stop interrupt> field in the dma channel control/status registers 0-31 is set). clearing the requests of a running channel results in unpredictable behavior.  0 = no effect on <request pending>  1 = clear all pending requests registered in <request pending>" "0,1"
        bitfld.long 0x00 0.--4. "         REQPEND100       ,request pending  indicates the number of pending requests on dreq." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD02000E8++0x03
    line.long 0x00 "DMA_RQSR2,DREQ Status Register 2"
        bitfld.long 0x00 8. " CLR107                   ,clearing pending request  writing 0x1 to this field clears the <request pending> field and thereby clears all pending requests made by the external dma request pin dreq. writing 0x0 to this field has no effect. this field can be used for clearing the requests if the channel mapped to dreq was prematurely stopped by software. this field must be set only after the mapped channel has stopped (<stop interrupt> field in the dma channel control/status registers 0-31 is set). clearing the requests of a running channel results in unpredictable behavior.  0 = no effect on <request pending>  1 = clear all pending requests registered in <request pending>" "0,1"
        bitfld.long 0x00 0.--4. "         REQPEND109       ,request pending  indicates the number of pending requests on dreq." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD02000F0++0x03
    line.long 0x00 "DMA_INT,DMA Interrupt Register"
        hexmask.long 0x00 0.--31. 1. " DM_CHLINTRX123           ,channel interrupt  this field indicates that dma channel x has been interrupted.  0 = no interrupt  1 = interrupt"

group d:0xD0200100++0x03
    line.long 0x00 "DMA_RCMRx0,DMA Request to Channel Map Registers 0-63 and 64-99"

group d:0xD0201100++0x03
    line.long 0x00 "DMA_RCMRx1,DMA Request to Channel Map Registers 0-63 and 64-99"
        bitfld.long 0x00 7. " DM_MAPVLD133             ,map valid channel  defines whether the request is mapped to a valid channel. if the field is set, the request is mapped to a valid channel indicated by <channel number>. if the field is cleared, the request is unmapped.  this bit can also be used to mask the request.  0 = request is unmapped  1 = request is mapped to a valid channel indicated by <channel number>" "0,1"
        bitfld.long 0x00 0.--4. "         DM_CHLNUM135     ,channel number  indicates the valid channel number if <map valid channel> is set. do not map two active requests to the same channel since it produces unpredictable results." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD0200200++0x03
    line.long 0x00 "DMA_DADRx,DMA Descriptor Address Registers"
        hexmask.long 0x00 4.--31. 1. " DM_DESCRIPTOR_ADDRESS150 ,descriptor address  contains address of next descriptor."
        bitfld.long 0x00 1. "  DM_BREN152       ,enable descriptor branch  works with the <descriptor compare status> field in the dma channel control/status registers 0-31 to determine which descriptor is fetched next. if both this field and <descriptor compare status> are set, the dmac fetches the next descriptor from (ddadrx + 32 bytes). if either of the bits is cleared, dmac fetches the next descriptor from the dma descriptor address registers.  this field is relevant only for descriptor-fetch transactions (<no-descriptor fetch> field in the dma channel control/status registers 0-31 = 0).  see dreq timing requirements figure for details about the operational flow.  0 = disable descriptor branching. fetch the next descriptor from register ddadrx.  1 = enable descriptor branching" "0,1"
        bitfld.long 0x00 0. "   DM_STOP153       ,stop  if this field is cleared, a new descriptor fetch based on dma descriptor address registers and other control information is initiated after the current descriptor is completely processed.  0 = run channel  1 = stop channel after completely processing this descriptor and before fetching the next descriptor (<length of the transfer in bytes> field in dma command registers 0-31 = 0)" "0,1"

group d:0xD0200204++0x03
    line.long 0x00 "DMA_SADRx,DMA Source Address Registers 0-31"
        hexmask.long 0x00 3.--31. 1. " DM_SRCADDR170            ,source address  source address of the on-chip peripheral, external peripheral, companion chip, or address of a memory location"
        bitfld.long 0x00 2. "  DM_SRCADDR2171   ,srcaddr[2] if <source address> is a memory location and alignment register is configured. see dma alignment register for programming details and restrictions.  srcaddr[2] if <source address> is an on-chip peripheral.  reserved for all companion-chip or external peripheral-related transfers.  reserved for special dma modes, such as compare modes." "0,1"
        bitfld.long 0x00 0.--1. "   DM_SRCADDR0172   ,srcaddr[1:0] if <source address> is a memory location and alignment register is configured. see dma alignment register for programming details and restrictions.  reserved if <source address> is an on-chip peripheral.  reserved for all companion-chip or external peripheral related transfers.  reserved for special dma modes, such as compare modes." "0,1,2,3"

group d:0xD0200208++0x03
    line.long 0x00 "DMA_TADRx,DMA Target Address Registers 0-31"
        hexmask.long 0x00 3.--31. 1. " DM_TRGADDR189            ,target address  target address of the on-chip peripheral, external peripheral, companion chip, or address of a memory location"
        bitfld.long 0x00 2. "  DM_TRGADDR2190   ,trgaddr[2] if <target address> is a memory location and alignment register is configured. see dma alignment register for programming details and restrictions.  trgaddr[2] if <target address> is an on-chip peripheral.  reserved for all companion-chip or external peripheral-related transfers.  reserved for special dma modes, such as compare modes." "0,1"
        bitfld.long 0x00 0.--1. "   DM_TRGADDR0191   ,trgaddr[1:0], if target address is a memory location and alignment register is configured. see dma alignment register for programming details and restrictions.  reserved if target address is an on-chip peripheral.  reserved for all companion-chip or external peripheral related transfers.  reserved for special dma modes, such as compare modes." "0,1,2,3"

group d:0xD020020C++0x03
    line.long 0x00 "DMA_CMDx,DMA Command Registers 0-31"
        bitfld.long 0x00 31. " DM_INCSRCADDR205         ,source address increment  if the source address is an internal peripheral fifo address or external i/o address, the address is not incremented on each successive access. in these cases, this field must be cleared.  0 = do not increment source address  1 = increment source address" "0,1"
        bitfld.long 0x00 30. "         DM_INCTRGADDR206 ,target address increment  if the target address is an internal peripheral fifo address or external i/o address, the address is not incremented on each successive accesses. in these cases, this field must be cleared.  0 = do not increment target address  1 = increment target address" "0,1"
        bitfld.long 0x00 29. "   DM_FLOWSRC207    ,source flow control  the flow control of the source bit must be set if the source is an on-chip peripheral or external companion chip.  setting both this field and <target flow control> causes unpredictable behavior.  0 = do not wait for request signals associated with this channel  1 = wait for a request signal before initiating the data transfer" "0,1"
        bitfld.long 0x00 28. "     DM_FLOWTRG208  ,target flow control  the flow control of the target bit must be set if the target is an on-chip peripheral or external companion chip.  setting both the <source flow control> and this field causes unpredictable behavior.  0 = do not wait for request signals associated with this channel  1 = wait for a request signal before initiating the data transfer" "0,1"
        textline "                          "
        bitfld.long 0x00 25. "DM_CMPEN210              ,descriptor compare enable  this field must be cleared for normal dma operations.  setting the field enables the descriptor-compare mode, in which the dmac treats the current descriptor as a special case and compares data that corresponds to the source and target fields.   <addrmode> is used to determine the addressing mode before the compare operation.  0 = dma does not perform any address-compare operations  1 = dma recognizes the current descriptor as a special case and compares data based on the source address and target address fields. if the compare is true, the channel's <descriptor compare status> field in the dma channel control/status registers 0-31 is set. if the compare is false, <descriptor compare status> is cleared." "0,1"
        bitfld.long 0x00 23. "         DM_ADDRMODE212   ,addressing mode  this field controls the addressing mode for descriptor comparison and is valid only in the descriptor compare mode (<descriptor compare enable> = 1).  reserved if <descriptor compare enable> = 0.  if <descriptor compare enable> is set, the bits specify the addressing modes of the source address and target address fields. if either field contains an address, the dmac fetches the data at that address and uses it for the compare operation.  0 = source address field contains address, and target address field contains address  1 = source address field contains address, and target address field contains data  if dalgnx is clear, then the lowest three bits of immediate data are forced to be 0 before comparison. if dalgnx is set, then the lowest three bits of immediate data are not forced to be 0 before comparison." "0,1"
        bitfld.long 0x00 22. "   DM_STARTIRQEN213 ,start interrupt enable  this field indicates that the interrupt is enabled as soon as the descriptor is loaded.   in no-descriptor-fetch transfers, this field is reserved.  0 = interrupt not triggered after descriptor is loaded  1 = set interrupt bit for that channel in the <channel interrupt> field in the dma interrupt register when the descriptor (4 words) for the channel is loaded" "0,1"
        bitfld.long 0x00 21. "     DM_ENDIRQEN214 ,end interrupt enable  0 = interrupt is not triggered when length decrements to zero.  1 = set the dint interrupt bit for the channel when length decrements to zero." "0,1"
        textline "                          "
        bitfld.long 0x00 16.--17. "DM_SIZE216               ,maximum burst size  maximum burst size of each data transfer  0x0 = reserved  0x1 = 8 bytes  0x2 = 16 bytes  0x3 = 32 bytes  the size must be less than or equal to the serviced peripheral fifo trigger threshold to properly handle the respective fifo trailing bytes." "0,1,2,3"
        bitfld.long 0x00 14.--15. "         DM_WIDTH217      ,width of the on-chip peripheral  this field is reserved for operations that do not involve on-chip peripherals, such as memory-to-memory moves and companion-chip-related operations.  width must be 0x0 for memory-to-memory moves or companion-chip-related operations.  0x0 = reserved for on-chip peripheral-related transactions  0x1 = 1 byte  0x2 = half-word (2 bytes)  0x3 = word (4 bytes)" "0,1,2,3"
        hexmask.long.word 0x00 0.--12. 1. "   DM_LEN219        ,length of the transfer in bytes  this field is the length of transfer in bytes. len = 0 means zero bytes for descriptor-fetch transactions. len = 0 is an invalid setting for no-descriptor-fetch transactions. programming len = 0 in the descriptor-fetch mode when <descriptor compare enable> is clear (normal data transfer mode) causes the channel to immediately discard the descriptor after it is fetched from memory. if the descriptor chain has more descriptors, the channel fetches the next valid descriptor. the channel stops if the descriptor chain has no more descriptors. the maximum transfer length is (8k-1) bytes.  if the transfer is of the memory-to-memory type, the length of the transfer may be any value (except for the len = 0 restriction in no-descriptor-fetch mode) up to a maximum of (8k -1) bytes. if the transfer involves an external peripheral (or a companion chip), then the length of the transfer must be an integer multiple of the peripheral fifo threshold (or water-mark).  if the transfer involves any of the on-chip peripherals, the length of the transfer must be as follows:"

group d:0xD0200000++0x03
    line.long 0x00 "DUMMY_REGISTER,This is a Dummy Register"
        hexmask.long 0x00 0.--31. 1. " DM_DUMMY234              ,this is a dummy register used as a workaround to fix an issue with the rev 2.21 perl script that requires another register follow the last include file (shown above). ignore this register as it will not show up in documentation anyway. (mclark)"

tree.end

tree "gpio"

width 12.

group d:0xD4019000++0x03
    line.long 0x00 "GPIO_PLR,GPIO Pin-Level Register"
        hexmask.long 0x00 0.--31. 1. " PLX    ,gpio port level n (where n = 0 through 31)   0 = port state is low  1 = port state is high"

group d:0xD401900C++0x03
    line.long 0x00 "GPIO_PDR,GPIO Pin Direction Register"
        hexmask.long 0x00 0.--31. 1. " PDX65  ,gpio port direction n (where n = 0 through 31)  0 = port configured as an input  1 = port configured as an output"

group d:0xD4019018++0x03
    line.long 0x00 "GPIO_PSR,GPIO Pin Output Set Register"
        hexmask.long 0x00 0.--31. 1. " PSX    ,gpio output port set n (where n = 0 through 31)  0 = port level unaffected  1 = if port configured as an output, set port level logic high"

group d:0xD4019024++0x03
    line.long 0x00 "GPIO_PCR,GPIO Pin Output Clear Register"
        hexmask.long 0x00 0.--31. 1. " PCX    ,gpio output port clear n (where n = 0 through 31)  0 = port level unaffected  1 = if port configured as an output, clear port level logic low"

group d:0xD4019030++0x03
    line.long 0x00 "GPIO_RER,GPIO Rising-Edge Detect Enable Register"
        hexmask.long 0x00 0.--31. 1. " REX    ,gpio port n rising-edge detect enable (where n = 0 through 31)  0 = disable rising-edge detect enable  1 = set corresponding gpio edge detect status register status bit when a rising edge is detected on the gpio port"

group d:0xD401903C++0x03
    line.long 0x00 "GPIO_FERx,GPIO Falling-Edge Detect Enable Register"
        hexmask.long 0x00 0.--31. 1. " FEX    ,gpio port falling-edge detect enable n (where n = 0 through 31)  0 = disable falling-edge detect enable  1 = set corresponding gpio edge detect status register status bit when a falling edge is detected on the gpio port"

group d:0xD4019048++0x03
    line.long 0x00 "GPIO_EDR,GPIO Edge Detect Status Register"
        hexmask.long 0x00 0.--31. 1. " EDX    ,gpio edge detect status n (where n = 0 through 31)  0 = no edge detect has occurred on the port as specified in gpio rising-edge detect enable and/or gpio falling-edge detect enable registers  1 = edge detect has occurred on the port as specified in the gpio rising-edge detect enable and/or gpio falling-edge detect enable registers"

group d:0xD4019054++0x03
    line.long 0x00 "GPIO_SDR,Bit-wise Set of GPIO Direction Register"
        hexmask.long 0x00 0.--31. 1. " PDX150 ,set gpio port direction n (where n = 0 through 31)  0 = gpio pin direction register bit not affected  1 = gpio pin direction register bit is set and gpiox function is set to output"

group d:0xD4019060++0x03
    line.long 0x00 "GPIO_CDR,Bit-wise Clear of GPIO Direction Register"
        hexmask.long 0x00 0.--31. 1. " PDX165 ,set gpio port direction n (where n = 0 through 31)  0 = gpio pin direction register bit not affected  1 = gpio pin direction register bit is cleared and gpio n function is set to input"

group d:0xD401906C++0x03
    line.long 0x00 "GPIO_SRERx,Bit-wise Set of GPIO Rising Edge Detect Enable Register"
        hexmask.long 0x00 0.--31. 1. " PDX183 ,set gpio rising edge detect enable n (where n = 0 through 31)  0 = gpio rising-edge detect enable register bit is not affected  1 = gpio rising-edge detect enable register bit is set"

group d:0xD4019078++0x03
    line.long 0x00 "GPIO_CRERx,Bit-wise Clear of GPIO Rising Edge Detect Enable Register"
        hexmask.long 0x00 0.--31. 1. " PDX190 ,clear gpio rising edge detect enable n (where n = 0 through 31)  0 = gpio rising-edge detect enable register bit is not affected  1 = gpio rising-edge detect enable register bit is cleared"

group d:0xD4019084++0x03
    line.long 0x00 "GPIO_SFER,Bit-wise Set of GPIO Falling Edge Detect Enable Register"
        hexmask.long 0x00 0.--31. 1. " PDX208 ,set gpio falling edge detect enable n (where n = 0 through 31)  0 = gpio falling-edge detect enable register bit not affected  1 = gpio falling-edge detect enable register bit is set"

group d:0xD4019090++0x03
    line.long 0x00 "GPIO_CFER,Bit-wise Clear of GPIO Falling Edge Detect Enable Register"
        hexmask.long 0x00 0.--31. 1. " PDX215 ,clear gpio falling edge detect enable n (where n = 0 through 31)  0 = gpio falling-edge detect enable register bit not affected  1 = gpio falling-edge detect enable register bit is cleared"

group d:0xD401909C++0x03
    line.long 0x00 "APMASK_REG,<var Processor: Mohawk> Bit-wise Mask of GPIO Edge Detect Register"
        hexmask.long 0x00 0.--31. 1. " PDX222 ,mask gpio edge detect n (where n = 0 through 31)  0 = gpio edge detects are masked   1 = gpio edge detects are not masked"

group d:0xD40190A8++0x03
    line.long 0x00 "CPMASK_REG,<var Processor: Comm> Bit-wise Mask of GPIO Edge Detect Register"
        hexmask.long 0x00 0.--31. 1. " PDX229 ,mask gpio edge detect n (where n = 0 through 31)  0 = gpio edge detects are masked   1 = gpio edge detects are not masked"

tree.end

tree "genericcounter"

width 9.

group d:0xD5001000++0x03
    line.long 0x00 "CNTCR,Counter Control Register,"
        bitfld.long 0x00 1. " HDBG14  ,halt on debug. the possible values are: 0 halt on debug, hltdbg signal into the counter has no effect. 1 halt on debug, hltdbg signal into the counter halts the counter" "0,1"
        bitfld.long 0x00 0. "         EN ,enable. the possible values are: 0 the counter is disabled and not incrementing. 1 the counter is enabled and is incrementing." "0,1"

group d:0xD5001004++0x03
    line.long 0x00 "CNTSR,Counter Status Register,"
        bitfld.long 0x00 1. " HDBG24  ,debug halted." "0,1"

group d:0xD5001008++0x03
    line.long 0x00 "CNTCVLW,Current value of counter[31:0]"
        hexmask.long 0x00 0.--31. 1. " CNTCVLW ,current value of counter[31:0]"

group d:0xD500100C++0x03
    line.long 0x00 "CNTCVUP,Current value of counter[63:32]"
        hexmask.long 0x00 0.--31. 1. " CNTCVUP ,current value of counter[63:32]"

group d:0xD5001020++0x03
    line.long 0x00 "CNTFID0,Base frequency ID"
        hexmask.long 0x00 0.--31. 1. " FREQ    ,frequency in number of ticks per second."

tree.end

tree "pwm"

width 9.

group d:0xD401A000++0x03
    line.long 0x00 "PWM_CRx,PWM Control Registers"
        bitfld.long 0x00 6. " SD ,pulse width modulator shutdown mode  0 = graceful shutdown of pwmx when the <var product number> stops the clocks to the pwm  1 = abrupt shutdown of pwmx when the <var product number> stops the clocks to the pwm" "0,1"
        hexmask.long.byte 0x00 0.--5. 1. "     PWM0_PRESCALE25 ,prescale  the scaled counter clock frequency is: <br>psclk_pwmx / (prescalex +1)"

group d:0xD401A004++0x03
    line.long 0x00 "PWM_DCR,PWM Duty Cycle Registers"
        bitfld.long 0x00 10. " FD ,full duty cycle  0 = pwm_outx is determined by the <duty cycle of pwm_outx> value  1 = pwm_outx is continuously asserted" "0,1"
        hexmask.long.word 0x00 0.--9. 1. "     DCYCLE          ,duty cycle of pwm_outx  0 = pwm_outx is continuously de-asserted  1 = pwm_outx is high for the number of 13 mhz clock periods equal to this field x (<prescale> in pwm control registers + 1)  if <full duty cycle> is set, this field has no effect on the output of pwmx."

group d:0xD401A008++0x03
    line.long 0x00 "PWM_PCR,PWM Period Control Registers"
        hexmask.long.word 0x00 0.--9. 1. " PV ,period value  the value of scaled clock cycles per cycle of pwm_outx plus one.  if all zeros are written to this register, the signal remains high."

tree.end

tree "resourceipc"

width 17.

group d:0xD40B0000++0x03
    line.long 0x00 "RIPCx_STATUS,RIPCx Status Register"
        bitfld.long 0x00 0. " RIPC0_STATUS24 ,see functional description for explanation on read/write values." "0,1"

group d:0xD40B0004++0x03
    line.long 0x00 "RIPCx_APPS_INT,RIPCx <var Processor: App> Core Interrupt Request Register"
        hexmask.long 0x00 1.--31. 1. " MSG32          ,resource ipc message  for software use"
        bitfld.long 0x00 0. "  INT_REQ33 ,write 1 = request an interrupt to relevant core when resource becomes free  software must clear this bit after the core receives the interrupt." "0,1"

group d:0xD40B0008++0x03
    line.long 0x00 "RIPCx_COMM_INT,RIPCx <var Processor: Comm> Core Interrupt Request Register"
        hexmask.long 0x00 1.--31. 1. " MSG40          ,resource ipc message  for software use"
        bitfld.long 0x00 0. "  INT_REQ41 ,write 1 = request an interrupt to relevant core when resource becomes free  software must clear this bit after the core receives the interrupt." "0,1"

group d:0xD40B000C++0x03
    line.long 0x00 "RIPCx_MSA_INT,RIPCx <var Processor: MSA> Core Interrupt Request Register"
        hexmask.long 0x00 1.--31. 1. " MSG48          ,resource ipc message  for software use"
        bitfld.long 0x00 0. "  INT_REQ49 ,write 1 = request an interrupt to relevant core when resource becomes free  software must clear this bit after the core receives the interrupt." "0,1"

group d:0xD40B0014++0x03
    line.long 0x00 "RIPCx_APPS_INFO,RIPCx <var Processor: App> Core Info Register"
        hexmask.long 0x00 0.--31. 1. " MSG56          ,resource ipc message  for software use"

group d:0xD40B0018++0x03
    line.long 0x00 "RIPCx_COMM_INFO,RIPCx <var Processor: Comm> Core Info Register"
        hexmask.long 0x00 0.--31. 1. " MSG63          ,resource ipc message  for software use"

group d:0xD40B001C++0x03
    line.long 0x00 "RIPCx_MSA_INFO,RIPCx <var Processor: MSA> Core Info Register"
        hexmask.long 0x00 0.--31. 1. " MSG70          ,resource ipc message  for software use"

tree.end

tree "pmuccu"

width 17.

group d:0xF00E0000++0x03
    line.long 0x00 "CCCR,Communication Subsystem Clock Configuration Register"
        bitfld.long 0x00 16. " L2CF      ,l2 cache clock force  0 = l2 cache clock is not forced  1 = l2 cache clock is always on" "0,1"
        bitfld.long 0x00 1.--3. "       CSCD      ,not used" "0,1,2,3,4,5,6,7"

group d:0xF00E0004++0x03
    line.long 0x00 "CCSR,Communication Subsystem Clock Status Register (not used any longer)"
        bitfld.long 0x00 1.--3. " CSCD_S    ,communication subsystem clock divider status  0x0 = reserved  0x1 = communication subsystem clock equals input clock divided by 1  0x2 = communication subsystem clock equals input clock divided by 2  0x3 = communication subsystem clock equals input clock divided by 3  0x4 = communication subsystem clock equals input clock divided by 4  0x5 = reserved  0x6 = reserved  0x7 = reserved  this bit is update after frequency change procedure completion (see gcccr f bit)." "0,1,2,3,4,5,6,7"

group d:0xF00E0008++0x03
    line.long 0x00 "GCCCR,Grayback Core Clock Control Register (not used any longer)"
        bitfld.long 0x00 0. " F         ,core frequency change  0 = no  core frequency change is performed  1 =  core frequency change sequence will begin when written  new cscd_s values must be programmed before setting the f bit.  software should not try to set the f bit when it is already a 1. doing so may result in undefined behavior." "0,1"

group d:0xF00E0100++0x03
    line.long 0x00 "MPCR,Communication Subsystem Power Control Register"
        bitfld.long 0x00 24. " LMP_REQ50 ,td modem power request  0 = disable lte modem power  1 = enable td modem power  changing the state of this bit initiates an immediate change. the actual status of the td modem power is indicated by cpsr[wms]. software should wait until the status matches the request before making a new request. power is always removed from lte when the msa system enters deep sleep. if this bit=1, then modem power will be on when gb power is on" "0,1"
        bitfld.long 0x00 23. "       LMP_REQ51 ,lte modem power request  0 = disable lte modem power  1 = enable lte modem power  changing the state of this bit initiates an immediate change. the actual status of the lte modem power is indicated by cpsr[wms]. software should wait until the status matches the request before making a new request. power is always removed from lte when the msa system enters deep sleep. if this bit=1, then modem power will be on when gb power is on" "0,1"
        bitfld.long 0x00 22. "  WMP_REQ ,w-cdma modem power request  0 = disable w-cdma modem power  1 = enable w-cdma modem power  changing the state of this bit initiates an immediate change. the actual status of the w-cdma modem power is indicated by cpsr[wms]. software should wait until the status matches the request before making a new request. power is always removed from w-cdma when the msa system enters deep sleep. if this bit=1, then modem power will be on when gb power is on" "0,1"
        bitfld.long 0x00 0.--1. "  PM  ,power mode select. <00> do not turn off msa power when msa sleep mode is reached <01 or 11> enter msa power off when msa sleep mode is reached <10> enter msa power off when msa sleep mode is reached and the modem slow clock has bb_d2_entry_ok signal asserted   deep sleep exit resets this bit to the value indicated in the reset row." "0,1,2,3"

group d:0xF00E0114++0x03
    line.long 0x00 "CMCR,Communication Subsystem Miscellaneous Counters Register "

group d:0xF00E0118++0x03
    line.long 0x00 "MPSR,Communication Subsystem Power Status Register"
        bitfld.long 0x00 28.--31. " CC_SWR70  ,software-controlled reset events tracking field. this field can be written (and read) to any value between 0x0 and 0xf. in order to track events through wdt reset events.  this field's content does not affect  functionality in any way" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7. "      TMS       ,td modem power status  0 = lte modem power disabled  1 = td modem power enabled." "0,1"
        bitfld.long 0x00 6. "  LMS     ,lte modem power status  0 = lte modem power disabled  1 = lte modem power enabled." "0,1"
        bitfld.long 0x00 5. "  WMS ,w-cdma modem power status  0 = w-cdma modem power disabled  1 = w-cdma modem power enabled." "0,1"
        textline "                           "
        bitfld.long 0x00 1. "LPM       ,deep sleep state exit reset  0 = has not occurred since the last time software or subsystem reset cleared this bit  1 = has occurred since the last time software or subsystem reset cleared this bit  when the system experiences a power on reset lpm field would be cleared." "0,1"

group d:0xF00E0120++0x03
    line.long 0x00 "CWER,Communication Subsystem general purpose wakeup enable"
        hexmask.long.tbyte 0x00 0.--17. 1. " CC_85     ,enable the general purpose wakeup"

group d:0xF00E0128++0x03
    line.long 0x00 "Cwesr_wakeup_en,Communication Subsystem general wakeup global enable"
        bitfld.long 0x00 31. " CC_93     ,reset the wakeup event to cp_" "0,1"
        bitfld.long 0x00 30. "       WAKEUP_EN ,the global wake enable signal for general purpose wakeup" "0,1"

group d:0xF00E0130++0x03
    line.long 0x00 "CIER,Communication Subsystem Interrupt Enable Register"
        bitfld.long 0x00 0. " FC_IE     ,frequency change interrupt enable  0 = do not generate an interrupt after a frequency change procedure is completed  1 = generate an interrupt after a frequency change procedure is completed" "0,1"

group d:0xF00E0140++0x03
    line.long 0x00 "CGDES,MSA Deep Sleep Entry Status Register"
        bitfld.long 0x00 0.--2. " GDES      ,msa core deep sleep entry status  this field is maintained entirely by msa core software to synchronize entry into deep sleep with the controller core.  deep sleep entry codes:  a (0x0) = core is running, no deep sleep -related activity in progress  d (0x6) = msa is in deep sleep state.  all other values are reserved." "0,1,2,3,4,5,6,7"

group d:0xF00E0200++0x03
    line.long 0x00 "CSSR,Communication Subsystem Spare Register"

tree.end

tree "timingctrl"

width 16.

group d:0xD401E7F8++0x03
    line.long 0x00 "AIB_spare0_reg,AIB spare0 Register"

group d:0xD401E7FC++0x03
    line.long 0x00 "AIB_spare1_reg,AIB spare1 Register"

tree.end

tree "uart"

width 10.

group d:0xD4017000++0x03
    line.long 0x00 "UART_RBR,Receive Buffer Register"
        hexmask.long.byte 0x00 24.--31. 1. " BYTE_324             ,byte 3  this field is only valid in 32-bit peripheral bus mode."
        hexmask.long.word 0x00 16.--24. 1. "    BYTE_225         ,byte 2  this field is only valid in 32-bit peripheral bus mode."
        hexmask.long.byte 0x00 8.--15. 1. "  BYTE_126       ,byte 1  this field is only valid in 32-bit peripheral bus mode."
        hexmask.long.byte 0x00 0.--7. 1. "  BYTE_027     ,byte 0"

group d:0xD4017000++0x03
    line.long 0x00 "UART_THR,Transmit Holding Register"
        hexmask.long.byte 0x00 24.--31. 1. " BYTE_335             ,byte 3  this field is only valid in 32-bit peripheral bus mode."
        hexmask.long.word 0x00 16.--24. 1. "    BYTE_236         ,byte 2  this field is only valid in 32-bit peripheral bus mode."
        hexmask.long.byte 0x00 8.--15. 1. "  BYTE_137       ,byte 1  this field is only valid in 32-bit peripheral bus mode."
        hexmask.long.byte 0x00 0.--7. 1. "  BYTE_038     ,byte 0"

group d:0xD4017000++0x03
    line.long 0x00 "UART_DLL,Divisor Latch Low Byte Register"
        hexmask.long.byte 0x00 0.--7. 1. " DLL                  ,divisor latch low  low-byte compare value to generate baud rate"

group d:0xD4017004++0x03
    line.long 0x00 "UART_DLH,Divisor Latch High Byte Register"
        hexmask.long.byte 0x00 0.--7. 1. " DLH                  ,divisor latch high  high-byte compare value to generate baud rate"

group d:0xD4017004++0x03
    line.long 0x00 "UART_IER,Interrupt Enable Register"
        bitfld.long 0x00 8. " HSE                  ,high speed uart enable  when high speed mode is enabled, the uart uses a 59.429 mhz input clock rather than a 14.857 mhz input clock. high speed mode should only be used for baud rates of 1.8 or 3.6 mbps.  0 = high speed mode is disabled (regular mode)  1 = high speed mode is enabled" "0,1"
        bitfld.long 0x00 7. "     DMAE             ,dma requests enable  0 = dma requests are disabled  1 = dma requests are enabled" "0,1"
        bitfld.long 0x00 6. "     UUE            ,uart unit enable  0 = unit is disabled  1 = unit is enabled" "0,1"
        bitfld.long 0x00 5. "   NRZE         ,nrz coding enable  nrz encoding/decoding is only used in uart mode, not in infrared mode. if the serial infrared receiver or transmitter is enabled, nrz coding is disabled.  0 = nrz coding disabled  1 = nrz coding enabled" "0,1"
        textline "                    "
        bitfld.long 0x00 4. "RTOIE                ,receiver time-out interrupt enable  the source for this field is the <time out detected> field in the interrupt identification register.  0 = receiver data time-out interrupt disabled  1 = receiver data time-out interrupt enabled" "0,1"
        bitfld.long 0x00 3. "     AP_UA_MIE80      ,modem interrupt enable  the source for this field is the <interrupt source encoded> field in the interrupt identification register.  0 = modem status interrupt disabled  1 = modem status interrupt enabled" "0,1"
        bitfld.long 0x00 2. "     RLSE           ,receiver line status interrupt enable  the source for this field is the <interrupt source encoded> field in the interrupt identification register.  0 = receiver line status interrupt disabled  1 = receiver line status interrupt enabled" "0,1"
        bitfld.long 0x00 1. "   AP_UA_TIE82  ,transmit data request interrupt enable  the source for this field is the <interrupt source encoded> field in the interrupt identification register.  0 = transmit fifo data request interrupt disabled  1 = transmit fifo data request interrupt enabled" "0,1"
        textline "                    "
        bitfld.long 0x00 0. "RAVIE                ,receiver data available interrupt enable  the source for this field is the <interrupt source encoded> field in the interrupt identification register.  0 = receiver data available (trigger threshold reached) interrupt disabled  1 = receiver data available (trigger threshold reached) interrupt enabled" "0,1"

group d:0xD4017008++0x03
    line.long 0x00 "UART_IIR,Interrupt Identification Register"
        bitfld.long 0x00 6.--7. " FIFOES10             ,fifo mode enable status  0x0 = non-fifo mode is selected  0x1 to 0x2 = reserved  0x3 = fifo mode is selected (<transmit and receive fifo enable> field in the fifo control register = 1)" "0,1,2,3"
        bitfld.long 0x00 5. "     AP_UA_EOC92      ,dma end of descriptor chain (see 32-bit peripheral bus section in the <var product number> datasheet)  0 = dma has not signaled the end of its programmed descriptor chain  1 = dma has signaled the end of its programmed descriptor chain" "0,1"
        bitfld.long 0x00 4. "     ABL            ,auto-baud lock (see auto-baud-rate detection section in the <var product number> datasheet)  0 = auto-baud circuitry has not programmed divisor latch registers  1 = divisor latch registers programmed by auto-baud circuitry" "0,1"
        bitfld.long 0x00 3. "   TOD          ,time out detected (see character timeout interrupt section in the <var product number> datasheet)  0 = no time out interrupt is pending  1 = time out interrupt is pending (fifo mode only)" "0,1"
        textline "                    "
        bitfld.long 0x00 1.--2. "IID10                ,interrupt source encoded  0x0 = modem status (cts, dsr, ri, dcd modem signals changed state)  0x1 = transmit fifo requests data  0x2 = received data available  0x3 = receive error (overrun, parity, framing, break, fifo error. see modem status register)" "0,1,2,3"
        bitfld.long 0x00 0. "     NIP              ,interrupt pending  0 = interrupt is pending (active low)  1 = no interrupt is pending" "0,1"

group d:0xD4017008++0x03
    line.long 0x00 "UART_FCR,FIFO Control Register"
        bitfld.long 0x00 6.--7. " ITL                  ,interrupt trigger level (threshold)  when the number of bytes in the receive fifo equals the interrupt trigger threshold programmed into this field and the received-data-available interrupt is enabled via the interrupt enable register, an interrupt is generated and appropriate bits are set in the interrupt identification register. the receive dma request is also generated when the trigger threshold is reached.   0x0 = 1 byte or more in fifo causes interrupt (not valid in dma mode)  0x1 = 8 bytes or more in fifo causes interrupt and dma request  0x2 = 16 bytes or more in fifo causes interrupt and dma request  0x3 = 32 bytes or more in fifo causes interrupt and dma request" "0,1,2,3"
        bitfld.long 0x00 5. "     BUS              ,32-bit peripheral bus  0 = 8-bit peripheral bus  1 = 32-bit peripheral bus" "0,1"
        bitfld.long 0x00 4. "     AP_UA_TRAIL124 ,trailing bytes  0 = trailing bytes are removed by the <var product number>   1 = trailing bytes are removed by the dmac" "0,1"
        bitfld.long 0x00 3. "   TIL          ,transmitter interrupt level  0 = interrupt/dma request when fifo is half empty  1 = interrupt/dma request when fifo is empty" "0,1"
        textline "                    "
        bitfld.long 0x00 2. "AP_UA_RESETTF126     ,reset transmit fifo  when this field is set, all the bytes in the transmit fifo are cleared. the <transmit data request> field in the line status register is set and the interrupt identification register shows a transmitter requests data interrupt, if the <transmit data request interrupt enable> field in the interrupt enable register is set. the transmit shift register is not cleared, and it completes the current transmission.  0 = writing 0 has no effect  1 = the transmit fifo is cleared" "0,1"
        bitfld.long 0x00 1. "     AP_UA_RESETRF127 ,reset receive fifo  when this field is set, all the bytes in the receive fifo are cleared. the <data ready> field in the line status register is reset to 0. all the error bits in the fifo and the <fifo error status> field in the line status register are cleared. any error bits, oe, pe, fe or bi, that had been set in the line status register are still set. the receive shift register is not cleared. if the interrupt identification register had been set to received data available, it is cleared.   0 = no effect  1 = the receive fifo is cleared" "0,1"
        bitfld.long 0x00 0. "     TRFIFOE        ,transmit and receive fifo enable  this field enables/disables the transmit and receive fifos. when set, both fifos are enabled (fifo mode). when clear, the fifos are both disabled (non-fifo mode). writing 0x0 to this field clears all bytes in both fifos. when changing from fifo mode to non-fifo mode and vice versa, data is cleared automatically from the fifos. this field must be set when other fields in this register are written or the other bits are not programmed.  0 = fifos are disabled  1 = fifos are enabled" "0,1"

group d:0xD401700C++0x03
    line.long 0x00 "UART_LCR,Line Control Register"
        bitfld.long 0x00 7. " DLAB                 ,divisor latch access bit  must be set to access the divisor latch registers of the baud-rate generator during a read or write operation. must be clear to access the receive buffer, the transmit holding register or the interrupt enable register.  0 = access transmit holding register, receive buffer register, and interrupt enable register  1 = access divisor latch registers (dll and dlh)" "0,1"
        bitfld.long 0x00 6. "     SB               ,set break  causes a break condition to be transmitted to the receiving uart. acts only on the txd pin and has no effect on the transmit logic. in fifo mode, wait until the transmitter is idle (<transmitter empty> field in the line status register = 1] to set and clear sb.  0 = no effect on txd output  1 = forces txd output to 0 (space)" "0,1"
        bitfld.long 0x00 5. "     STKYP          ,sticky parity  forces the bit value at the parity bit location to be the opposite of the <even parity select> field rather than the parity value. this stops parity generation. if <parity enable> = 0, this field is ignored.  0 = no effect on parity bit  1 = forces parity bit to be opposite of <even parity select> field value" "0,1"
        bitfld.long 0x00 4. "   AP_UA_EPS141 ,even parity select  if <parity enable> = 0, this field is ignored.  0 = sends or checks for odd parity  1 = sends or checks for even parity" "0,1"
        textline "                    "
        bitfld.long 0x00 3. "PEN                  ,parity enable  this field enables a parity bit to be generated on transmission or checked on reception.   0 = no parity  1 = parity" "0,1"
        bitfld.long 0x00 2. "     STB              ,stop bits  specifies the number of stop bits transmitted and received in each character. when receiving, the receiver checks only the first stop bit.  this field must be clear.  0 = 1 stop bit" "0,1"
        bitfld.long 0x00 0.--1. "     WLS10          ,word length select  specifies the number of data bits in each transmitted or received character.  0x0, 0x1, 0x2 = 7-bit character  0x3 = 8-bit character" "0,1,2,3"

group d:0xD4017010++0x03
    line.long 0x00 "UART_MCR,Modem Control Register"
        bitfld.long 0x00 5. " AFE                  ,auto-flow control enable  0 = auto-rts and auto-cts are disabled  1 = auto-cts is enabled. if <request to send> is also set, both auto-cts and auto-rts are enabled." "0,1"
        bitfld.long 0x00 4. "     LOOP             ,loopback mode  this field provides a local loopback feature for diagnostic testing of the uart. when set, the following occurs: the transmitter serial output is set to a logic 1 state. the receiver serial input is disconnected from the pin. the output of the transmit shift register is <q>looped back</q> into the receive shift register input. the four modem control inputs (ctsn, dsrn, dcdn, and rin) are disconnected from the pins and the modem control output pins (rtsn and dtrn) are forced to their inactive state.  coming out of the loopback mode may result in unpredictable activation of the delta bits (bits 30) in the modem status register. marvell recommends that the modem status register be read once to clear its delta bits.  loopback mode must be configured before the uart is enabled.  the lower four bits of this register are connected to the upper four modem status register bits." "0,1"
        bitfld.long 0x00 3. "     OUT2           ,out2 signal control  out2 connects the uart interrupt output to the interrupt controller unit. when <loopback mode> is clear  0 = uart interrupt is disabled  1 = uart interrupt is enabled  when <loopback mode> is set, interrupts always go to the <var product number>  0 = <data carrier detect> field in the modem status register forced to 0  1 = <data carrier detect> field forced to 1" "0,1"
        bitfld.long 0x00 2. "   OUT1         ,test bit  this field is only used in loopback mode. otherwise, it is ignored.  0 = force <ring indicator> field in the modem status register to 0  1 = force <ring indicator> field to 1" "0,1"
        textline "                    "
        bitfld.long 0x00 1. "RTS                  ,request to send  0 = non-auto-flow mode  rtsn pin is 1  auto-rts disabled. auto-flow works only with auto-cts.  1 = auto-flow mode  rtsn pin is 0  auto-rts enabled. auto-flow works with both auto-cts and auto-rts." "0,1"
        bitfld.long 0x00 0. "     DTR              ,data terminal ready  0 = dtrn pin is 1  1 = dtrn pin is 0" "0,1"

group d:0xD4017014++0x03
    line.long 0x00 "UART_LSR,Line Status Register"
        bitfld.long 0x00 7. " FIFOE                ,fifo error status  in non-fifo mode, this bit is clear. in fifo mode, this field is set when there is at least one parity error, framing error, or break indication for any of the characters in the fifo. a <var product number> read of the this register does not reset this field. this field is reset when all erroneous characters have been read from the fifo. if dma requests are enabled (<dma requests enable> field in the interrupt enable register set) and this field is set, the error interrupt is generated, and no receive dma request is generated even when the receive fifo reaches the trigger threshold. once the errors have been cleared by reading the fifo, dma requests are re-enabled automatically. if dma requests are not enabled (<dma requests enable> field clear), this field set does not generate an error interrupt.  0 = no fifo or no errors in receive fifo  1 = at least one character in receive fifo has errors" "0,1"
        bitfld.long 0x00 6. "     AP_UA_TEMT178    ,transmitter empty  set when the transmit holding register and the transmit shift register are both empty. it is cleared when either the transmit holding register or the transmit shift register contains a data character. in fifo mode, this field is set when the transmit fifo and the transmit shift register are both empty.  0 = there is data in the transmit shift register, the transmit holding register, or the fifo  1 = all the data in the transmitter has been shifted out" "0,1"
        bitfld.long 0x00 5. "     TDRQ           ,transmit data request  this field indicates that the uart is ready to accept a new character for transmission. in addition, this field causes the uart to issue an interrupt to the <var product number> when the transmit data request interrupt enable is set and generates the dma request to the dma controller if dma requests and fifo mode are enabled. this field is set when a character is transferred from the transmit holding register into the transmit shift register. this field is cleared with the loading of the transmit holding register. in fifo mode, this field is set when half of the characters in the fifo have been loaded into the transmit shift register or the <reset transmit fifo> field in the fifo control register has been set. it is cleared when the fifo has more than half data. if more than 64 characters are loaded into the fifo, the excess characters are lost.  0 = there is data in the holding register or fifo waiting to be shifted out  1 = the transmit fifo has half or less than half data" "0,1"
        bitfld.long 0x00 4. "   BI           ,break interrupt  this field is set when the received data input is held low for longer than a full-word transmission time (the total time of start bit + data bits + parity bit + stop bit). it is cleared when the <var product number> reads the lsr. in fifo mode, only one character equal to 0x00, is loaded into the fifo regardless of the length of the break condition. bi shows the break condition for the character at the front of the fifo, not the most recently received character.  0 = no break signal has been received  1 = break signal received" "0,1"
        textline "                    "
        bitfld.long 0x00 3. "FE                   ,framing error  this field indicates that the received character did not have a valid stop bit. it is set when the bit following the last data bit or parity bit is detected to be 0. it is cleared when the <var product number> reads this register. the uart will resynchronize after a framing error. to do this, it assumes that the framing error was due to the next start bit, so it samples this start bit twice and then reads in the data. in fifo mode, this field shows a framing error for the character at the front of the fifo, not for the most recently received character.  0 = no framing error  1 = invalid stop bit has been detected" "0,1"
        bitfld.long 0x00 2. "     AP_UA_PE182      ,parity error  indicates that the received data character does not have the correct even or odd parity, as selected by the even parity select bit. this field is set upon detection of a parity error and is cleared when the <var product number> reads this register. in fifo mode, this field shows a parity error for the character at the front of the fifo, not the most recently received character.   0 = no parity error  1 = parity error has occurred" "0,1"
        bitfld.long 0x00 1. "     OE             ,overrun error  in non-fifo mode, indicates that data in the receive buffer register was not read by the <var product number> before the next character was received. the new character is lost. in fifo mode, this field indicates that all 64 bytes of the fifo are full and the most recently received byte has been discarded. this field is set upon detection of an overrun condition and cleared when the <var product number> reads this register.  0 = no data has been lost  1 = receive data has been lost" "0,1"
        bitfld.long 0x00 0. "   DR           ,data ready  set when a complete incoming character has been received and transferred into the receive buffer register or the fifo. in non-fifo mode, this field is cleared when the receive buffer is read. in fifo mode, this field is cleared if the fifo is empty (last character has been read from receive buffer register) or the fifo is reset with the <reset receive fifo> field in the fifo control register.  0 = no data has been received  1 = data is available in receive buffer register or the fifo" "0,1"

group d:0xD4017018++0x03
    line.long 0x00 "UART_MSR,Modem Status Register"
        bitfld.long 0x00 7. " DCD                  ,data carrier detect  complement of the data-carrier-detect (dcdn) input. equivalent to <out2 signal control> field in the modem control register if <loopback mode> is set in the modem control register.  0 = dcdn pin is 1  1 = dcdn pin is 0" "0,1"
        bitfld.long 0x00 6. "     RI               ,ring indicator  complement of the ring-indicator (rin) input. equivalent to <test bit> field in the modem control register if <loopback mode> is set.  0 = rin pin is 1  1 = rin pin is 0" "0,1"
        bitfld.long 0x00 5. "     DSR            ,data set ready  complement of the data-set-ready (dsrn) input. equivalent to <data terminal ready> field in the modem control register if <loopback mode> is set.  0 = dsrn pin is 1  1 = dsrn pin is 0" "0,1"
        bitfld.long 0x00 4. "   CTS          ,clear to send  complement of the clear-to-send (ctsn) input. equivalent to <request to send> field in the modem control register if <loopback mode> is set.  0 = ctsn pin is 1  1 = ctsn pin is 0" "0,1"
        textline "                    "
        bitfld.long 0x00 3. "DDCD                 ,delta data carrier detect  0 = no change in dcdn pin since last read of this register  1 = dcdn pin has changed state" "0,1"
        bitfld.long 0x00 2. "     TERI             ,trailing edge ring indicator  0 = rin pin has not changed from 0 to 1 since last read of this register  1 = rin pin has changed state" "0,1"
        bitfld.long 0x00 1. "     DDSR           ,delta data set ready  0 = no change in dsrn pin since last read of this register  1 = dsrn pin has changed state" "0,1"
        bitfld.long 0x00 0. "   DCTS         ,delta clear to send  0 = no change in ctsn pin since last read of this register  1 = ctsn pin has changed state" "0,1"

group d:0xD401701C++0x03
    line.long 0x00 "UART_SCR,Scratchpad Register"
        hexmask.long.byte 0x00 0.--7. 1. " SCRATCHPAD           ,scratchpad  this field has no effect on uart functions."

group d:0xD4017020++0x03
    line.long 0x00 "UART_ISR,Infrared Selection Register"
        bitfld.long 0x00 4. " RXPL                 ,receive data polarity  0 = sir decoder takes positive pulses as zeros  1 = sir decoder takes negative pulses as zeros" "0,1"
        bitfld.long 0x00 3. "     TXPL             ,transmit data polarity  0 = sir encoder generates a positive pulse for a data bit of 0  1 = sir encoder generates a negative pulse for a data bit of 0" "0,1"
        bitfld.long 0x00 2. "     XMODE          ,transmit pulse width select  when this field is clear, the uart 16x clock is used to clock the irda transmit and receive logic. when this field is set, receive decoder operation does not change, and the transmit encoder generates 1.6 ms pulses (that are 3/16 of a bit time at 115.2 kbps) instead of pulses 3/16 of a bit time wide. marvell recommends setting this field.  0 = transmit pulse width is 3/16 of a bit time wide  1 = transmit pulse width is 1.6 ms" "0,1"
        bitfld.long 0x00 1. "   RCVEIR       ,receiver sir enable  when this field is set, the signal from the rxd pin is processed by the irda decoder before it is fed to the uart. if this field is clear, then all clocking to the irda decoder is blocked and the rxd pin is fed directly to the uart.  0 = receiver is in uart mode  1 = receiver is in infrared mode" "0,1"
        textline "                    "
        bitfld.long 0x00 0. "XMITIR               ,transmitter sir enable  when this field is set, the normal txd output from the uart is processed by the irda encoder before it is fed to the device pin. if this field is clear, all clocking to the irda encoder is blocked and the uart's txd signal is connected directly to the device pin.  when transmitter sir enable is set, the txd output pin, which is in a normally high default state, switches to a normally low default state. this can cause a false start bit unless the infrared led is disabled before this field is set.  0 = transmitter is in uart mode  1 = transmitter is in infrared mode" "0,1"

group d:0xD4017024++0x03
    line.long 0x00 "UART_FOR,Receive FIFO Occupancy Register"
        hexmask.long.byte 0x00 0.--5. 1. " BYTE_COUNT           ,byte count  this field is used for the number of bytes (0-63) remaining in the receive fifo."

group d:0xD4017028++0x03
    line.long 0x00 "UART_ABR,Auto-Baud Control Register"
        bitfld.long 0x00 3. " ABT                  ,abt  0 = formula used to calculate baud rates, allowing all possible baud rates to be chosen by uart as shown in section 9.4.2.1.2  1 = table used to calculate baud rates, which limits uart to choosing common baud rates" "0,1"
        bitfld.long 0x00 2. "     ABUP             ,abup  0 = <var product number> programs divisor latch registers  1 = uart programs divisor latch registers" "0,1"
        bitfld.long 0x00 1. "     ABLIE          ,ablie  0 = auto-baud-lock interrupt disabled (source <auto-baud lock> field)  1 = auto-baud-lock interrupt enabled (source <auto-baud lock> field)" "0,1"
        bitfld.long 0x00 0. "   ABE          ,abe  0 = auto-baud disabled  1 = auto-baud enabled" "0,1"

group d:0xD401702C++0x03
    line.long 0x00 "UART_ACR,Auto-Baud Count Register"
        hexmask.long.word 0x00 0.--15. 1. " AP_UA_COUNT_VALUE265 ,count value  this field is used for the number of 14.857-mhz clock cycles within a start-bit pulse."

tree.end

tree "mimir"

width 27.

group d:0xC0500000++0x03
    line.long 0x00 "GPU_ID,   Contains information related to the model and revision of the GPU.  Removed GPU IDs and product_id_t.  Removed erroneous PRODUCT_ID field. "
        hexmask.long.byte 0x00 4.--11. 1. " VERSION_MINOR             ,   It contains the minor release number of the GPU. This is the 'P' part of an 'RnPn' release number. "
        bitfld.long 0x00 12.--15. "                                            VERSION_MAJOR          ,   It contains the major release number of the GPU. This is the 'R' part of an 'RnPn' release number. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "                                            PRODUCT_MAJOR        ,   This field contains a value indicating a product release within a product generation implementing a particular major version of the architecture.  The first product implementing a particular major version of the architecture would have 0 in this field. In order that this is not affected by release scheduling, it is recommended that this number is allocated early in the project.  For example, since the Mali-T820, Mali-T860, Mali-T830, and Mali-T880 GPUs are based on the same major architecture version, they would have been labelled products 0, 1, 2 and 3 under this scheme.  To identify a single product, regardless of revisions, it is sufficient to look only at the  ARCH_MAJOR and PRODUCT_MAJOR fields.       This is to avoid the problem of reallocating PRODUCT_MAJOR IDs at every minor version of the architecture. So, for example, assume that the Mimir GPU was released at architecture revision 6.0.7, and assigned  PRODUCT_MAJOR ID 0 . If we then release a new GPU called (say) Thunnorad at architecture version 6.0.9, then this would be assigned  PRODUCT_MAJOR ID 1 , as it is the second product for       major architecture version 6, not the first product at minor architecture version 6.0.9. This also allows us to also update Mimir to 6.0.9 at a future release without having to reassign its  PRODUCT_MAJOR ID. Clarified what parts of the product ID identify a product as opposed to revisions. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "                                            ARCH_MINOR                ,   This field contains the minor revision value for the version of the architecture implemented by this hardware. For example, for architecture version 6.1.0, this field would be set to 1. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 28.--31. "ARCH_MAJOR                ,   This field contains the major revision value for the version of the architecture implemented by this hardware. For example, for architecture version 6.1.0, this field would be set to 6. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "                                            ARCH_REV               ,   This field contains the patch revision value for the version of the architecture implemented by this hardware.      This is a signed value to allow for preview releases, so for instance previews of Architecture spec version 6.1.0 might be labelled 6.1.-8 and 6.1.-7. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "                                            VERSION_STATUS       ,   It contains the status of the GPU release. This has no architecturally defined values, but should reset to 0  at each minor or major release, and increases by one for each intermediate release status (alpha, beta, EAC, etc.)  The named values indicated here will be valid for one particular implementation only.  VERSION_STATUS should be reset to 0 at each minor or major release.  VERSION_STATUS is now defined as an enum included from the implementation config file. " "beta:  Beta ,dev_15:  Development release 15 ,eac:  EAC ,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC0500004++0x03
    line.long 0x00 "L2_FEATURES,   Contains information about the features of the level 2 cache. "
        hexmask.long.byte 0x00 0.--7. 1. " LINE_SIZE                 ,   It contains the base-2 logarithm of the cache's line size, in bytes. "
        hexmask.long.byte 0x00 8.--15. 1. "                                            ASSOCIATIVITY          ,   It contains the base-2 logarithm of the cache's associativity (number of ways). "
        hexmask.long.byte 0x00 16.--23. 1. "                                            CACHE_SIZE           ,   It contains the base-2 logarithm of the cache's total size, in bytes. "
        hexmask.long.byte 0x00 24.--31. 1. "                                            EXTERNAL_BUS_WIDTH        ,   It contains the base-2 logarithm of the cache's external data bus size, in bits. "

group d:0xC050000C++0x03
    line.long 0x00 "TILER_FEATURES,   Contains information about the features of the tiler. "
        bitfld.long 0x00 6.--7. " Res1                      ,Res1" "0,1,2,3"
        hexmask.long.tbyte 0x00 12.--31. 1. "                                             Res2                   ,Res2"
        hexmask.long.byte 0x00 0.--5. 1. "                                        BIN_SIZE             ,   It contains the base-2 logarithm of the tiler's bin size, in bytes. "
        bitfld.long 0x00 8.--11. "                                            MAX_LEVELS                ,   It specifies the maximum number of hierarchy levels may be enabled at any one time. This is the maximum number of '1' bits in the Hierarchy Mask field of the Frame Buffer Descriptor. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC0500010++0x03
    line.long 0x00 "MEM_FEATURES,   Contains information about the features of the memory system. "
        hexmask.long.byte 0x00 2.--7. 1. " Res3                      ,Res3"
        hexmask.long.tbyte 0x00 12.--31. 1. "                                            Res4                   ,Res4"
        bitfld.long 0x00 8.--11. "                                        L2_SLICES            ,   It contains the number of slices in the level 2 cache, minus 1. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0. "                                            COHERENT_CORE_GROUP       ,COHERENT_CORE_GROUP" "false,true"
        textline "                                     "
        bitfld.long 0x00 1. "COHERENT_SUPER_GROUP      ,COHERENT_SUPER_GROUP" "false,true"

group d:0xC0500014++0x03
    line.long 0x00 "MMU_FEATURES,   Describes the configuration of the Memory Management Unit in the GPU. "
        hexmask.long.byte 0x00 24.--31. 1. " Res5                      ,Res5"
        hexmask.long.byte 0x00 0.--7. 1. "                                            VA_BITS                ,   The number of bits which are significant for virtual addresses. All 64 bits of an address are decoded, but only the region from 0 to 2  VA_BITS -1 can be mapped to physical memory. Other address ranges result in a translation fault."
        hexmask.long.byte 0x00 8.--15. 1. "                                            PA_BITS              ,   The number of bits which are significant for physical addresses. All 64 bits of an address are decoded, but only the region from 0 to 2  PA_BITS -1 corresponds to real physical memory. Other address ranges result in a translation fault.       Note that this does not guarantee that this amount of physical memory is actually available, just that there is the potential to attach it exists."
        hexmask.long.byte 0x00 16.--23. 1. "                                            IPA_BITS                  ,   The number of bits which are significant for intermediate physical addresses. All 64 bits of an address are decoded, but only the region from 0 to 2  IPA_BITS -1 correspond to addressable intermediate-physical memory. Other address ranges result in a translation fault. If this is 0, this indicates that there is no Stage 2 translation. In this case, the Stage 1 translation therefore translates directly from virtual addresses to physical addresses.  Added  IPA_BITS to MMU_FEATURES register."

group d:0xC0500018++0x03
    line.long 0x00 "AS_PRESENT,   Contains information about which address spaces are present on this GPU. "
        hexmask.long 0x00 0.--31. 1. " AS_PRESENT                ,   Indicates which address spaces are actually available in the hardware. "

group d:0xC050001C++0x03
    line.long 0x00 "JS_PRESENT,   Contains information about which job slots are present on this GPU. "
        hexmask.long 0x00 0.--31. 1. " JS_PRESENT                ,   Indicates which job slots are actually available in the hardware. "

group d:0xC0500020++0x03
    line.long 0x00 "GPU_IRQ_RAWSTAT,   This register contains the raw unmasked interrupt sources for GPU-wide status and exception handling.  Writing to this register will force bits on, but will not clear them. The new state is the logical OR of the previous state and the written value.  Writing a zero to a bit will have no effect. Use the GPU_IRQ_CLEAR register to clear interrupts. "
        hexmask.long.byte 0x00 1.--6. 1. " Res6                      ,Res6"
        bitfld.long 0x00 11.--15. "                                            Res7                   ,Res7" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        hexmask.long.word 0x00 18.--31. 1. "                                            Res8                 ,Res8"
        bitfld.long 0x00 0. "                                          GPU_FAULT                 ,GPU_FAULT" "false:    No GPU fault. ,true"
        textline "                                     "
        bitfld.long 0x00 7. "MULTIPLE_GPU_FAULTS       ,MULTIPLE_GPU_FAULTS" "false:    No multiple fault. ,true"
        bitfld.long 0x00 8. "                 RESET_COMPLETED        ,   Modified reset values for registers. " "false,true"
        bitfld.long 0x00 9. "                                         POWER_CHANGED_SINGLE ,POWER_CHANGED_SINGLE" "false:    No power changes. ,true"
        bitfld.long 0x00 10. "                  POWER_CHANGED_ALL         ,POWER_CHANGED_ALL" "false:    No power changes. ,true"
        textline "                                     "
        bitfld.long 0x00 16. "PRFCNT_SAMPLE_COMPLETED   ,PRFCNT_SAMPLE_COMPLETED" "false,true"
        bitfld.long 0x00 17. "                                         CLEAN_CACHES_COMPLETED ,CLEAN_CACHES_COMPLETED" "false,true"

group d:0xC0500024++0x03
    line.long 0x00 "GPU_IRQ_CLEAR,   This register has the same layout as GPU_IRQ_RAWSTAT. Write a one to a bit in this register to clear the corresponding bit in GPU_IRQ_RAWSTAT. "
        hexmask.long.byte 0x00 1.--6. 1. " Res9                      ,Res9"
        bitfld.long 0x00 11.--15. "                                            Res10                  ,Res10" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        hexmask.long.word 0x00 18.--31. 1. "                                            Res11                ,Res11"
        bitfld.long 0x00 0. "                                          GPU_FAULT                 ,GPU_FAULT" "false:    No GPU fault. ,true"
        textline "                                     "
        bitfld.long 0x00 7. "MULTIPLE_GPU_FAULTS       ,MULTIPLE_GPU_FAULTS" "false:    No multiple fault. ,true"
        bitfld.long 0x00 8. "                 RESET_COMPLETED        ,   Modified reset values for registers. " "false,true"
        bitfld.long 0x00 9. "                                         POWER_CHANGED_SINGLE ,POWER_CHANGED_SINGLE" "false:    No power changes. ,true"
        bitfld.long 0x00 10. "                  POWER_CHANGED_ALL         ,POWER_CHANGED_ALL" "false:    No power changes. ,true"
        textline "                                     "
        bitfld.long 0x00 16. "PRFCNT_SAMPLE_COMPLETED   ,PRFCNT_SAMPLE_COMPLETED" "false,true"
        bitfld.long 0x00 17. "                                         CLEAN_CACHES_COMPLETED ,CLEAN_CACHES_COMPLETED" "false,true"

group d:0xC0500028++0x03
    line.long 0x00 "GPU_IRQ_MASK,   This register has the same layout as GPU_IRQ_RAWSTAT. Set each bit in this to one to enable the corresponding interrupt source, and to zero to disable it. "
        hexmask.long.byte 0x00 1.--6. 1. " Res12                     ,Res12"
        bitfld.long 0x00 11.--15. "                                            Res13                  ,Res13" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        hexmask.long.word 0x00 18.--31. 1. "                                            Res14                ,Res14"
        bitfld.long 0x00 0. "                                          GPU_FAULT                 ,GPU_FAULT" "false:    No GPU fault. ,true"
        textline "                                     "
        bitfld.long 0x00 7. "MULTIPLE_GPU_FAULTS       ,MULTIPLE_GPU_FAULTS" "false:    No multiple fault. ,true"
        bitfld.long 0x00 8. "                 RESET_COMPLETED        ,   Modified reset values for registers. " "false,true"
        bitfld.long 0x00 9. "                                         POWER_CHANGED_SINGLE ,POWER_CHANGED_SINGLE" "false:    No power changes. ,true"
        bitfld.long 0x00 10. "                  POWER_CHANGED_ALL         ,POWER_CHANGED_ALL" "false:    No power changes. ,true"
        textline "                                     "
        bitfld.long 0x00 16. "PRFCNT_SAMPLE_COMPLETED   ,PRFCNT_SAMPLE_COMPLETED" "false,true"
        bitfld.long 0x00 17. "                                         CLEAN_CACHES_COMPLETED ,CLEAN_CACHES_COMPLETED" "false,true"

group d:0xC050002C++0x03
    line.long 0x00 "GPU_IRQ_STATUS,   This register has the same layout as GPU_IRQ_RAWSTAT. This register contains the result of anding together GPU_IRQ_RAWSTAT and GPU_IRQ_MASK. If any bits in this register are set, the external GPU control interrupt line is asserted, signaling an interrupt request to the CPU. "
        hexmask.long.byte 0x00 1.--6. 1. " Res15                     ,Res15"
        bitfld.long 0x00 11.--15. "                                            Res16                  ,Res16" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        hexmask.long.word 0x00 18.--31. 1. "                                            Res17                ,Res17"
        bitfld.long 0x00 0. "                                          GPU_FAULT                 ,GPU_FAULT" "false:    No GPU fault. ,true"
        textline "                                     "
        bitfld.long 0x00 7. "MULTIPLE_GPU_FAULTS       ,MULTIPLE_GPU_FAULTS" "false:    No multiple fault. ,true"
        bitfld.long 0x00 8. "                 RESET_COMPLETED        ,   Modified reset values for registers. " "false,true"
        bitfld.long 0x00 9. "                                         POWER_CHANGED_SINGLE ,POWER_CHANGED_SINGLE" "false:    No power changes. ,true"
        bitfld.long 0x00 10. "                  POWER_CHANGED_ALL         ,POWER_CHANGED_ALL" "false:    No power changes. ,true"
        textline "                                     "
        bitfld.long 0x00 16. "PRFCNT_SAMPLE_COMPLETED   ,PRFCNT_SAMPLE_COMPLETED" "false,true"
        bitfld.long 0x00 17. "                                         CLEAN_CACHES_COMPLETED ,CLEAN_CACHES_COMPLETED" "false,true"

group d:0xC0500030++0x03
    line.long 0x00 "GPU_COMMAND,   Writing values to this register will perform GPU-wide commands.  During SOFT_RESET or HARD_RESET commands, the Job Manager retains the value of GPU_IRQ_MASK[RESET_COMPLETED]. "
        hexmask.long 0x00 0.--31. 1. " GPU_COMMAND               ,   Added SET_SECURE_MODE to GPU_COMMAND register.  Changed SET_SECURE_MODE to SET_PROTECTED_MODE. "

group d:0xC0500034++0x03
    line.long 0x00 "GPU_STATUS,   The GPU status register contains a set of flags showing the overall state of the GPU. "
        hexmask.long.tbyte 0x00 8.--31. 1. " Res18                     ,Res18"
        bitfld.long 0x00 0. "                                        GPU_ACTIVE             ,GPU_ACTIVE" "false,true"
        bitfld.long 0x00 1. "                                         PWR_ACTIVE           ,PWR_ACTIVE" "false,true"
        bitfld.long 0x00 2. "                                         PRFCNT_ACTIVE             ,PRFCNT_ACTIVE" "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "JOB_ACTIVE                ,JOB_ACTIVE" "false,true"
        bitfld.long 0x00 4. "                                         PAGE_FAULT             ,PAGE_FAULT" "false,true"
        bitfld.long 0x00 5. "                                         IRQ_ACTIVE           ,IRQ_ACTIVE" "false,true"
        bitfld.long 0x00 6. "                                         CYCLE_COUNT_ACTIVE        ,CYCLE_COUNT_ACTIVE" "false,true"
        textline "                                     "
        bitfld.long 0x00 7. "PROTECTED_MODE_ACTIVE     ,   Added protected mode indicator to GPU_STATUS register. " "false,true"

group d:0xC0500038++0x03
    line.long 0x00 "LATEST_FLUSH,   If cache flush reduction is enabled, then this register contains the Flush ID associated with the lastest clean-and-invalidate operation.  This value is set to 0xFFFFE0 on reset, and incremented by the hardware every time a cache flush is performed by the GPU.  When enqueuing a new job chain, the value in this register should be used to set the  FLUSH_ID_NEXT register of the new job chain.      It is then possible for the GPU to determine if the GPU cache has already been flushed since submission of the job. If so, we may be able to      determine that the memory state between CPU and GPU is already consistent and the GPU need not issue another cache flush. Further details on which cache flushes may be suppressed can be found in the description of the  ENABLE_FLUSH_REDUCTION flag."
        hexmask.long.byte 0x00 24.--31. 1. " Res19                     ,Res19"
        hexmask.long.tbyte 0x00 0.--23. 1. "                                            FLUSH_ID               ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 24-bit value. When the job manager is asked to perform a flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is equal to the latest flush, then a flush is performed.  Care must be taken in the overflow case. If the software setting up the ID detects that an overflow may occur, the job chain should be tagged with the maximum value of the  LATEST_FLUSH register. This ensures that flushes are correctly performed, at the possible cost of a few redundant flushes. Added cache flush reduction  LATEST_FLUSH.flush_id field narrowed to 24 bits, changed reset value.  Cache flush actually happens when FLUSH_ID_NEXT is equal to LATEST_FLUSH in flush reduction mode. "

group d:0xC050003C++0x03
    line.long 0x00 "GPU_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.  See  ExceptionStatus for details on the contents and layout of the fault status value. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. Software must indicate that it has handled the fault by clearing the appropriate interrupt bit.  If the GPU is in protected mode, this register will read as zero.  Changed access type of GPU_FAULTSTATUS register when in protected mode. "
        hexmask.long.tbyte 0x00 8.--31. 1. " exception_data            , This can be interpretted as a bitfield that may include access type and source ID. "
        hexmask.long.byte 0x00 0.--7. 1. "                                        exception_type         ,   Added new MMU exception types.  Changed INTERRUPTED exception type to SUSPENDED.  Added exception types for new events EUREKA and KABOOM.  Removed aliases for OK - used to also be called IDLE and NOT_STARTED.  Documented that a KABOOM instruction will cause other jobs to hard-stop.  Removed OUT_OF_MEMORY_AFBC error as it can only occur with non-sparse allocation (now removed).  Removed INSTR_TYPE_MISMATCH, INSTR_OPERAND_FAULT, INSTR_TLS_FAULT, INSTR_ALIGN_FAULT; added IMPRECISE_FAULT (0x5B).  Split SHAREABILITY_FAULT into GPU_SHAREABILITY_FAULT, SYSTEM_SHAREABILITY_FAULT and GPU_CACHEABILITY_FAULT. "

group d:0xC0500040++0x03
    line.long 0x00 "GPU_FAULTADDRESS_LO,   If a GPU exception occurs, then the physical address causing the fault is shown in this register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. Software must indicate that it has handled the fault by clearing the appropriate interrupt bit. "
        hexmask.long 0x00 0.--31. 1. " GPU_FAULTADDRESS_LO       ,   It contains the physical address at which the GPU fault occurred. "

group d:0xC0500044++0x03
    line.long 0x00 "GPU_FAULTADDRESS_HI,   If a GPU exception occurs, then the physical address causing the fault is shown in this register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. Software must indicate that it has handled the fault by clearing the appropriate interrupt bit. "
        hexmask.long 0x00 0.--31. 1. " GPU_FAULTADDRESS_HI       ,   It contains the physical address at which the GPU fault occurred. "

group d:0xC0500050++0x03
    line.long 0x00 "PWR_KEY,   The power manager key register must be written before any of the power control override registers can be written to.  Since incorrectly setting any of the PWR_OVERRIDEn registers may potentially lock up or damage a device, they are write protected by default.  By writing the value 0x2968A819 to this register, the PWR_OVERRIDEn registers are temporarily made writable. The next write access to the GPU can then update them. If writing multiple registers, the PWR_KEY register must be written before each register is updated.  The registers are write protected automatically after any write access to the GPU. If the first write after unlocking the registers are not to any of the power override registers, the registers are still write protected, causing any later update attempt to be ignored. "
        hexmask.long 0x00 0.--31. 1. " PWR_KEY                   ,   It must be written with the value 0x2968A819 to unlock writes to the other power state registers. This key value was generated at random, and has no special significance except that it is unlikely to occur by chance. "

group d:0xC0500054++0x03
    line.long 0x00 "PWR_OVERRIDE0,   The power manager override register 0 allows aspects of how individual cores are powered up and down to be overridden.  This register is write protected by default. A special key value must be written to the PWR_KEY register to allow this register to be updated.  The override fields allow the low-level signals used for controlling power gating to behave differently from normal. This can be used for testing, or for working around power gating problems. As such, they require low-level understanding of the implementation details of the power domain controller.  The override values are propagated to individual power domains on any power up or power down operation. To change the override modes for a power domain, the power state of the domain must be changed. Domains that are powered on must be powered off, and domains that are powered off must be powered on.  Writing to this register while any power change commands are pending is  UNDEFINED . Setting incorrect values in this register may cause  UNPREDICTABLE behaviour of the entire system. Do not write to this register unless explicitly specified by the device manufacturer. The only guaranteed safe value for this register is 0. Removed CLKEN_OVERRIDE from PWR_OVERRIDE0 register. "
        bitfld.long 0x00 6.--7. " Res20                     ,Res20" "0,1,2,3"
        bitfld.long 0x00 22. "                                             Res21                  ,Res21" "0,1"
        bitfld.long 0x00 30.--31. "                                             Res22                ,Res22" "0,1,2,3"
        hexmask.long.byte 0x00 16.--21. 1. "                                             PWRTRANS_LIMIT            ,   It contains the number of power domains which may be in transition at any one time, minus 1. "
        textline "                                     "
        hexmask.long.byte 0x00 24.--29. 1. "THROTTLE_LIMIT            ,   This field contains the number of shader cores which may be in startup at any one time, minus 1.       A core is considered to be starting after the core is sent a task (load_descriptor/run),       until the first response to a RUN command (which includes LOAD_DESCRIPTOR with run_immediately).  If the  THROTTLE_ENABLE flag is clear, then this field is ignored. The intent of this is to smooth out sudden changes in dynamic power, in a similar way to how  PWRTRANS_LIMIT smooths out sudden changes in static power. Added core startup throttling fields to PWR_OVERRIDE0 "
        bitfld.long 0x00 0.--1. "                                            PWRUP_OVERRIDE         ,   It overrides the handling of the power manager's PWRUP signal. " "OVERRIDE_NONE:  The signal behaves normally ,OVERRIDE_INVERT,OVERRIDE_ON,OVERRIDE_OFF"
        bitfld.long 0x00 2.--3. "  ISOLATE_OVERRIDE     ,   It overrides the handling of the power manager's ISOLATE signal. " "OVERRIDE_NONE:  The signal behaves normally ,OVERRIDE_INVERT,OVERRIDE_ON,OVERRIDE_OFF"
        bitfld.long 0x00 4.--5. "  RESET_OVERRIDE            ,   It overrides the handling of the power manager's RESET signal. " "OVERRIDE_NONE:  The signal behaves normally ,OVERRIDE_INVERT,OVERRIDE_ON,OVERRIDE_OFF"
        textline "                                     "
        bitfld.long 0x00 8.--9. "PWRUP_ACK_OVERRIDE        ,   It overrides the handling of the power manager's PWRUP signal. " "OVERRIDE_NONE:  The signal behaves normally ,OVERRIDE_INVERT,OVERRIDE_ON,OVERRIDE_OFF"
        bitfld.long 0x00 10.--11. "  ISOLATE_ACK_OVERRIDE   ,   It overrides the handling of the power manager's PWRUP signal. " "OVERRIDE_NONE:  The signal behaves normally ,OVERRIDE_INVERT,OVERRIDE_ON,OVERRIDE_OFF"
        bitfld.long 0x00 12.--13. "  FUNC_ISO_OVERRIDE    ,   It overrides the handling of the power manager's FUNC_ISOLATE signal.  Added FUNC_ISO_OVERRIDE field to PWR_OVERRIDE0 register. " "OVERRIDE_NONE:  The signal behaves normally ,OVERRIDE_INVERT,OVERRIDE_ON,OVERRIDE_OFF"
        bitfld.long 0x00 14.--15. "  FUNC_ISO_ACK_OVERRIDE     ,   It overrides the handling of the power manager's FUNC_ISOLATE_ACK signal.  Added FUNC_ISO_ACK_OVERRIDE field to PWR_OVERRIDE0 register. " "OVERRIDE_NONE:  The signal behaves normally ,OVERRIDE_INVERT,OVERRIDE_ON,OVERRIDE_OFF"
        textline "                                     "
        bitfld.long 0x00 23. "THROTTLE_ENABLE           ,THROTTLE_ENABLE" "false,true"

group d:0xC0500058++0x03
    line.long 0x00 "PWR_OVERRIDE1,   In addition to the power control values in power manager override register 0, the device manufacturer may also choose to use this register to affect how power management behaves.  Setting incorrect values in this register may cause  UNPREDICTABLE behaviour of the entire system. Do not write to this register unless explicitly specified by the device manufacturer. The only guaranteed safe value for this register is 0."
        hexmask.long 0x00 0.--31. 1. " PWR_OVERRIDE1             ,   System-specific power control values. "

group d:0xC0500060++0x03
    line.long 0x00 "PRFCNT_BASE_LO,   This register contains the start of a memory region where the performance counter values can be written. The required size of this are depends on the GPU configuration and the setting in the PRFCNT_CONFIG register.  The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the PRFCNT_CONFIG register.  Writing to this register while the GPU is active and the performance counters are enabled is  UNDEFINED ."
        hexmask.long 0x00 0.--31. 1. " PRFCNT_BASE_LO            ,   It contains the base address of performance counter write area. "

group d:0xC0500064++0x03
    line.long 0x00 "PRFCNT_BASE_HI,   This register contains the start of a memory region where the performance counter values can be written. The required size of this are depends on the GPU configuration and the setting in the PRFCNT_CONFIG register.  The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the PRFCNT_CONFIG register.  Writing to this register while the GPU is active and the performance counters are enabled is  UNDEFINED ."
        hexmask.long 0x00 0.--31. 1. " PRFCNT_BASE_HI            ,   It contains the base address of performance counter write area. "

group d:0xC0500068++0x03
    line.long 0x00 "PRFCNT_CONFIG,   The performance counter configuration register controls how the performance counters work. For more details, see the section on Performance Counters. "
        hexmask.long.tbyte 0x00 9.--31. 1. " Res23                     ,Res23"
        bitfld.long 0x00 4.--7. "                                        ADDRESS_SPACE          ,   It contains the address space ID (ASID) used to translate virtual addresses when writing the performance counters to memory. Changing address space while the GPU is active and the counters are enabled is  UNDEFINED . Specifying an address space that is not supported (i.e. the corresponding bit in AS_PRESENT is 0) is UNDEFINED ." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "                                            MODE                 ,   Manual counter writing no longer automatically clears counters. Tiled mode is unchanged.  Manual counter writing reverted to clear counters, new MANUAL_NO_CLEAR mode added. " "OFF,MANUAL,TILE,MANUAL_NO_CLEAR,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8. "                               SET_SELECT                ,   This flag allows selection of additional sets of counter events.        For those counter blocks that support it, this effectively selects between two sets of the event count inputs to the same counter block.        Since there is only one flag, all functional blocks are switched at the same time.        During switching, the counter values become  UNDEFINED as they may register counts from a mixture of sources.        It is therefore recommended that, after switching, performance counters are cleared by writing PRFCNT_CLEAR to the GPU_COMMAND register. Added  SET_SELECT flag to PRFCNT_CONFIG ." "false,true"

group d:0xC050006C++0x03
    line.long 0x00 "PRFCNT_JM_EN,   Performance counter enable for Job Manager. "
        hexmask.long 0x00 0.--31. 1. " PRFCNT_JM_EN              ,   The main use for this register is to reduce the bandwidth required to write out the performance counters to memory, and so reduce the impact the counters have on the performance of the GPU.  Bit 0 controls the writing of the performance metadata - the time stamp and counter enable mask.  Writing to these registers while performance counters are enabled is  UNDEFINED . Writing to these registers while the corresponding cores are powered off has no effect. "

group d:0xC0500070++0x03
    line.long 0x00 "PRFCNT_SHADER_EN,   Performance counter enable for shader cores. "
        hexmask.long 0x00 0.--31. 1. " PRFCNT_SHADER_EN          ,   The main use for this register is to reduce the bandwidth required to write out the performance counters to memory, and so reduce the impact the counters have on the performance of the GPU.  Bit 0 controls the writing of the performance metadata - the time stamp and counter enable mask.  Writing to these registers while performance counters are enabled is  UNDEFINED . Writing to these registers while the corresponding cores are powered off has no effect. "

group d:0xC0500074++0x03
    line.long 0x00 "PRFCNT_TILER_EN,   Performance counter enable for tiler. "
        hexmask.long 0x00 0.--31. 1. " PRFCNT_TILER_EN           ,   The main use for this register is to reduce the bandwidth required to write out the performance counters to memory, and so reduce the impact the counters have on the performance of the GPU.  Bit 0 controls the writing of the performance metadata - the time stamp and counter enable mask.  Writing to these registers while performance counters are enabled is  UNDEFINED . Writing to these registers while the corresponding cores are powered off has no effect. "

group d:0xC050007C++0x03
    line.long 0x00 "PRFCNT_MMU_L2_EN,   Performance counter enable for memory management unit and level 2 cache. "
        hexmask.long 0x00 0.--31. 1. " PRFCNT_MMU_L2_EN          ,   The main use for this register is to reduce the bandwidth required to write out the performance counters to memory, and so reduce the impact the counters have on the performance of the GPU.  Bit 0 controls the writing of the performance metadata - the time stamp and counter enable mask.  Writing to these registers while performance counters are enabled is  UNDEFINED . Writing to these registers while the corresponding cores are powered off has no effect. "

group d:0xC0500090++0x03
    line.long 0x00 "CYCLE_COUNT_LO,   The Job Manager contains a 64-bit cycle counter. This counter simply counts the number of clock cycles since it was started, the frequency of which is determined by the system as a whole and which may change due to voltage and frequency scaling. It therefore does not have a unique, fixed relationship with real time, but is guaranteed to be nondecreasing unless reset, and is very fine grained.  It is readable through the CYCLE_COUNT register, and can also be written to memory by a write value job.  This counter value is sent to each shader core, ensuring that all cores have a consistent and synchronized value readable from the shader.  The counter must be explicitly started. After reset the counter has value zero but is not running. To start the counter, issue a CYCLE_COUNT_START command to the GPU_COMMAND register.  When the GPU is not used, the counter should be stopped to reduce power consumption. To stop the counter, issue a CYCLE_COUNT_STOP command to the GPU_COMMAND register.  Note that this is implemented separately from, and in addition to, a system-wide constant-frequency counter "
        hexmask.long 0x00 0.--31. 1. " CYCLE_COUNT_LO            ,   It contains the number of GPU clock cycles since the counter was started. "

group d:0xC0500094++0x03
    line.long 0x00 "CYCLE_COUNT_HI,   The Job Manager contains a 64-bit cycle counter. This counter simply counts the number of clock cycles since it was started, the frequency of which is determined by the system as a whole and which may change due to voltage and frequency scaling. It therefore does not have a unique, fixed relationship with real time, but is guaranteed to be nondecreasing unless reset, and is very fine grained.  It is readable through the CYCLE_COUNT register, and can also be written to memory by a write value job.  This counter value is sent to each shader core, ensuring that all cores have a consistent and synchronized value readable from the shader.  The counter must be explicitly started. After reset the counter has value zero but is not running. To start the counter, issue a CYCLE_COUNT_START command to the GPU_COMMAND register.  When the GPU is not used, the counter should be stopped to reduce power consumption. To stop the counter, issue a CYCLE_COUNT_STOP command to the GPU_COMMAND register.  Note that this is implemented separately from, and in addition to, a system-wide constant-frequency counter "
        hexmask.long 0x00 0.--31. 1. " CYCLE_COUNT_HI            ,   It contains the number of GPU clock cycles since the counter was started. "

group d:0xC0500098++0x03
    line.long 0x00 "TIMESTAMP_LO,   This is a handy point from which the system global timestamp counter can be read. The value is the current broadcast value of the system time counter, as described in [7], which has a fixed relationship with real time and is coherent system-wide.  Although the time stamp value is continually updated externally from the GPU, propagation of the time stamp value to the GPU must be explicitly started in the same manned as the CYCLE_COUNT register, above.  So, after reset the current local copy of the timestamp has value zero and is not being actively updated. To start updates, issue a CYCLE_COUNT_START command to the GPU_COMMAND register.  When the GPU is not used, time stamp updates should be stopped to reduce power consumption. To stop the update, issue a CYCLE_COUNT_STOP command to the GPU_COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " TIMESTAMP_LO              ,   It contains the global time stamp value. "

group d:0xC050009C++0x03
    line.long 0x00 "TIMESTAMP_HI,   This is a handy point from which the system global timestamp counter can be read. The value is the current broadcast value of the system time counter, as described in [7], which has a fixed relationship with real time and is coherent system-wide.  Although the time stamp value is continually updated externally from the GPU, propagation of the time stamp value to the GPU must be explicitly started in the same manned as the CYCLE_COUNT register, above.  So, after reset the current local copy of the timestamp has value zero and is not being actively updated. To start updates, issue a CYCLE_COUNT_START command to the GPU_COMMAND register.  When the GPU is not used, time stamp updates should be stopped to reduce power consumption. To stop the update, issue a CYCLE_COUNT_STOP command to the GPU_COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " TIMESTAMP_HI              ,   It contains the global time stamp value. "

group d:0xC05000A0++0x03
    line.long 0x00 "THREAD_MAX_THREADS,   The maximum number of threads that can be in flight on each core. If this register is 0, then the information is not available on this implementation of the GPU. "
        hexmask.long 0x00 0.--31. 1. " THREAD_MAX_THREADS        ,   It contains the maximum number of threads per core. "

group d:0xC05000A4++0x03
    line.long 0x00 "THREAD_MAX_WORKGROUP_SIZE,   The maximum number of threads in a single workgroup. If this register is 0, then the information is not available on this implementation of the GPU. "
        hexmask.long 0x00 0.--31. 1. " THREAD_MAX_WORKGROUP_SIZE ,   It contains the maximum number of threads in a single workgroup. "

group d:0xC05000A8++0x03
    line.long 0x00 "THREAD_MAX_BARRIER_SIZE,   The maximum number of threads which may be simultaneously waiting at a hardware barrier. If this register is 0, then the information is not available on this implementation of the GPU. "
        hexmask.long 0x00 0.--31. 1. " THREAD_MAX_BARRIER_SIZE   ,   It contains the maximum number of threads waiting at a barrier. "

group d:0xC05000AC++0x03
    line.long 0x00 "THREAD_FEATURES,   Describes other features of the GPUs threading system. If this register is 0, then the information is not available on this implementation of the GPU. "
        hexmask.long.word 0x00 0.--15. 1. " MAX_REGISTERS             ,   It contains the total size of the register file available per core. Each register is 32 bits in size. "
        hexmask.long.byte 0x00 16.--23. 1. "                                          MAX_TASK_QUEUE         ,   It contains the maximum number of tasks which may be sent to a core before it becomes blocked. "
        hexmask.long.byte 0x00 24.--29. 1. "                                            MAX_TG_SPLIT         ,   This field contains the maximum allowed value of the  thread_group_split field in a job descriptor. This must be at least big enough to represent the largest supported workgroup size, even if this is represented using a non-compact encoding.        An example of this would be a workgroup of size 5x5x5 work items which takes 9 bits rather than the expected 7 bits to encode.        So for the relatively common maximum workgroup size of 256, this would need to be 10 or more.  Changed value of MAX_TG_SPLIT to 10, added note on why it has this value. "
        bitfld.long 0x00 30.--31. "                                            IMPLEMENTATION_TECHNOLOGY ,IMPLEMENTATION_TECHNOLOGY" "NOT_SPECIFIED,SILICON,FPGA,SOFTWARE"

group d:0xC05000B0++0x03
    line.long 0x00 "TEXTURE_FEATURES_0,   Contains information about which job slots are present on this GPU. "
        hexmask.long 0x00 0.--31. 1. " TEXTURE_FEATURES_0        ,   Indicates which indexed texture formats are actually available in the hardware. "

group d:0xC05000B4++0x03
    line.long 0x00 "TEXTURE_FEATURES_1,   Each bit in this register indicates that the texture unit supports a specific indexed texture format in the range 32..63. "
        hexmask.long 0x00 0.--31. 1. " TEXTURE_FEATURES_1        ,   Indicates which indexed texture formats are actually available in the hardware. "

group d:0xC05000B8++0x03
    line.long 0x00 "TEXTURE_FEATURES_2,   Each bit in this register indicates that the texture unit supports a specific indexed texture format in the range 64..95. "
        hexmask.long 0x00 0.--31. 1. " TEXTURE_FEATURES_2        ,   Indicates which indexed texture formats are actually available in the hardware. "

group d:0xC05000C0++0x03
    line.long 0x00 "JS0_FEATURES,   Contains various information of the features of Job Slot 0. "
        bitfld.long 0x00 0. " Res24                     ,Res24" "0,1"
        bitfld.long 0x00 8. "                                             Res25                  ,Res25" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res26                ,Res26"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000C4++0x03
    line.long 0x00 "JS1_FEATURES,   Contains various information of the features of Job Slot 1. "
        bitfld.long 0x00 0. " Res27                     ,Res27" "0,1"
        bitfld.long 0x00 8. "                                             Res28                  ,Res28" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res29                ,Res29"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000C8++0x03
    line.long 0x00 "JS2_FEATURES,   Contains various information of the features of Job Slot 2. "
        bitfld.long 0x00 0. " Res30                     ,Res30" "0,1"
        bitfld.long 0x00 8. "                                             Res31                  ,Res31" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res32                ,Res32"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000CC++0x03
    line.long 0x00 "JS3_FEATURES,   Contains various information of the features of Job Slot 3. "
        bitfld.long 0x00 0. " Res33                     ,Res33" "0,1"
        bitfld.long 0x00 8. "                                             Res34                  ,Res34" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res35                ,Res35"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000D0++0x03
    line.long 0x00 "JS4_FEATURES,   Contains various information of the features of Job Slot 4. "
        bitfld.long 0x00 0. " Res36                     ,Res36" "0,1"
        bitfld.long 0x00 8. "                                             Res37                  ,Res37" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res38                ,Res38"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000D4++0x03
    line.long 0x00 "JS5_FEATURES,   Contains various information of the features of Job Slot 5. "
        bitfld.long 0x00 0. " Res39                     ,Res39" "0,1"
        bitfld.long 0x00 8. "                                             Res40                  ,Res40" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res41                ,Res41"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000D8++0x03
    line.long 0x00 "JS6_FEATURES,   Contains various information of the features of Job Slot 6. "
        bitfld.long 0x00 0. " Res42                     ,Res42" "0,1"
        bitfld.long 0x00 8. "                                             Res43                  ,Res43" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res44                ,Res44"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000DC++0x03
    line.long 0x00 "JS7_FEATURES,   Contains various information of the features of Job Slot 7. "
        bitfld.long 0x00 0. " Res45                     ,Res45" "0,1"
        bitfld.long 0x00 8. "                                             Res46                  ,Res46" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res47                ,Res47"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000E0++0x03
    line.long 0x00 "JS8_FEATURES,   Contains various information of the features of Job Slot 8. "
        bitfld.long 0x00 0. " Res48                     ,Res48" "0,1"
        bitfld.long 0x00 8. "                                             Res49                  ,Res49" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res50                ,Res50"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000E4++0x03
    line.long 0x00 "JS9_FEATURES,   Contains various information of the features of Job Slot 9. "
        bitfld.long 0x00 0. " Res51                     ,Res51" "0,1"
        bitfld.long 0x00 8. "                                             Res52                  ,Res52" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res53                ,Res53"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000E8++0x03
    line.long 0x00 "JS10_FEATURES,   Contains various information of the features of Job Slot 10. "
        bitfld.long 0x00 0. " Res54                     ,Res54" "0,1"
        bitfld.long 0x00 8. "                                             Res55                  ,Res55" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res56                ,Res56"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000EC++0x03
    line.long 0x00 "JS11_FEATURES,   Contains various information of the features of Job Slot 11. "
        bitfld.long 0x00 0. " Res57                     ,Res57" "0,1"
        bitfld.long 0x00 8. "                                             Res58                  ,Res58" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res59                ,Res59"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000F0++0x03
    line.long 0x00 "JS12_FEATURES,   Contains various information of the features of Job Slot 12. "
        bitfld.long 0x00 0. " Res60                     ,Res60" "0,1"
        bitfld.long 0x00 8. "                                             Res61                  ,Res61" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res62                ,Res62"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000F4++0x03
    line.long 0x00 "JS13_FEATURES,   Contains various information of the features of Job Slot 13. "
        bitfld.long 0x00 0. " Res63                     ,Res63" "0,1"
        bitfld.long 0x00 8. "                                             Res64                  ,Res64" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res65                ,Res65"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000F8++0x03
    line.long 0x00 "JS14_FEATURES,   Contains various information of the features of Job Slot 14. "
        bitfld.long 0x00 0. " Res66                     ,Res66" "0,1"
        bitfld.long 0x00 8. "                                             Res67                  ,Res67" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res68                ,Res68"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC05000FC++0x03
    line.long 0x00 "JS15_FEATURES,   Contains various information of the features of Job Slot 15. "
        bitfld.long 0x00 0. " Res69                     ,Res69" "0,1"
        bitfld.long 0x00 8. "                                             Res70                  ,Res70" "0,1"
        hexmask.long.tbyte 0x00 11.--31. 1. "                                             Res71                ,Res71"
        bitfld.long 0x00 1. "                                        NULL                      ,NULL" "false,true"
        textline "                                     "
        bitfld.long 0x00 2. "WRITE_VALUE               ,   Corrected two references to Set value job. " "false,true"
        bitfld.long 0x00 3. "                                         CACHE_FLUSH            ,CACHE_FLUSH" "false,true"
        bitfld.long 0x00 4. "                                         COMPUTE_SHADER       ,COMPUTE_SHADER" "false,true"
        bitfld.long 0x00 5. "                                         VERTEX_SHADER             ,VERTEX_SHADER" "false,true"
        textline "                                     "
        bitfld.long 0x00 6. "GEOMETRY_SHADER           ,GEOMETRY_SHADER" "false,true"
        bitfld.long 0x00 7. "                                         TILER                  ,TILER" "false,true"
        bitfld.long 0x00 9. "                                         FRAGMENT_SHADER      ,FRAGMENT_SHADER" "false,true"
        bitfld.long 0x00 10. "                                         INDEXED_VERTEX_SHADER     ,   Added INDEXED_VERTEX_SHADER flag to  JSn_FEATURES registers." "false,true"

group d:0xC0500100++0x03
    line.long 0x00 "SHADER_PRESENT_LO,SHADER_PRESENT_LO"
        hexmask.long 0x00 0.--31. 1. " SHADER_PRESENT_LO         ,   Indicates which shader cores are actually available in the hardware. "

group d:0xC0500104++0x03
    line.long 0x00 "SHADER_PRESENT_HI,SHADER_PRESENT_HI"
        hexmask.long 0x00 0.--31. 1. " SHADER_PRESENT_HI         ,   Indicates which shader cores are actually available in the hardware. "

group d:0xC0500110++0x03
    line.long 0x00 "TILER_PRESENT_LO,TILER_PRESENT_LO"
        hexmask.long 0x00 0.--31. 1. " TILER_PRESENT_LO          ,   Indicates which tilers are actually available in the hardware. "

group d:0xC0500114++0x03
    line.long 0x00 "TILER_PRESENT_HI,TILER_PRESENT_HI"
        hexmask.long 0x00 0.--31. 1. " TILER_PRESENT_HI          ,   Indicates which tilers are actually available in the hardware. "

group d:0xC0500120++0x03
    line.long 0x00 "L2_PRESENT_LO,L2_PRESENT_LO"
        hexmask.long 0x00 0.--31. 1. " L2_PRESENT_LO             ,   Indicates which Level 2 caches are actually available in the hardware.  Where a number of shader cores share a L2 cache instance, the L2 cache instance is reported on the lowest-numbered core. "

group d:0xC0500124++0x03
    line.long 0x00 "L2_PRESENT_HI,L2_PRESENT_HI"
        hexmask.long 0x00 0.--31. 1. " L2_PRESENT_HI             ,   Indicates which Level 2 caches are actually available in the hardware.  Where a number of shader cores share a L2 cache instance, the L2 cache instance is reported on the lowest-numbered core. "

group d:0xC0500140++0x03
    line.long 0x00 "SHADER_READY_LO,SHADER_READY_LO"
        hexmask.long 0x00 0.--31. 1. " SHADER_READY_LO           ,   Indicates which shader cores are powered up and ready. "

group d:0xC0500144++0x03
    line.long 0x00 "SHADER_READY_HI,SHADER_READY_HI"
        hexmask.long 0x00 0.--31. 1. " SHADER_READY_HI           ,   Indicates which shader cores are powered up and ready. "

group d:0xC0500150++0x03
    line.long 0x00 "TILER_READY_LO,TILER_READY_LO"
        hexmask.long 0x00 0.--31. 1. " TILER_READY_LO            ,   Indicates which tiler units are powered up and ready. "

group d:0xC0500154++0x03
    line.long 0x00 "TILER_READY_HI,TILER_READY_HI"
        hexmask.long 0x00 0.--31. 1. " TILER_READY_HI            ,   Indicates which tiler units are powered up and ready. "

group d:0xC0500160++0x03
    line.long 0x00 "L2_READY_LO,L2_READY_LO"
        hexmask.long 0x00 0.--31. 1. " L2_READY_LO               ,   Indicates which level 2 caches are powered up and ready. "

group d:0xC0500164++0x03
    line.long 0x00 "L2_READY_HI,L2_READY_HI"
        hexmask.long 0x00 0.--31. 1. " L2_READY_HI               ,   Indicates which level 2 caches are powered up and ready. "

group d:0xC0500180++0x03
    line.long 0x00 "SHADER_PWRON_LO,SHADER_PWRON_LO"
        hexmask.long 0x00 0.--31. 1. " SHADER_PWRON_LO           ,   Requests that shader cores are to be powered on. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC0500184++0x03
    line.long 0x00 "SHADER_PWRON_HI,SHADER_PWRON_HI"
        hexmask.long 0x00 0.--31. 1. " SHADER_PWRON_HI           ,   Requests that shader cores are to be powered on. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC0500190++0x03
    line.long 0x00 "TILER_PWRON_LO,TILER_PWRON_LO"
        hexmask.long 0x00 0.--31. 1. " TILER_PWRON_LO            ,   Requests that tiler units are to be powered on. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC0500194++0x03
    line.long 0x00 "TILER_PWRON_HI,TILER_PWRON_HI"
        hexmask.long 0x00 0.--31. 1. " TILER_PWRON_HI            ,   Requests that tiler units are to be powered on. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC05001A0++0x03
    line.long 0x00 "L2_PWRON_LO,L2_PWRON_LO"
        hexmask.long 0x00 0.--31. 1. " L2_PWRON_LO               ,   Requests that level 2 caches are to be powered on. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC05001A4++0x03
    line.long 0x00 "L2_PWRON_HI,L2_PWRON_HI"
        hexmask.long 0x00 0.--31. 1. " L2_PWRON_HI               ,   Requests that level 2 caches are to be powered on. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC05001C0++0x03
    line.long 0x00 "SHADER_PWROFF_LO,SHADER_PWROFF_LO"
        hexmask.long 0x00 0.--31. 1. " SHADER_PWROFF_LO          ,   Requests that shader cores are to be powered off. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED . Power domains may contain multiple cores. In this case, a power domain must not be powered off until all cores within that domain are marked as powered off.        A core will therefore never be powered off 'implicitly' by powering down another core, but it may be kept powered if it shares a power domain with another active core.        It is therefore necessary to know the relationship between cores and power domains to determine the most appropriate set of cores to power down.  The relationship of cores to power domains is implementation dependent.         It often depends not only on the GPU model, but also on the details of system integration, and may vary across different system designs from the same vendor.        Please refer to implementation notes for your system to determine the mapping of cores to power domains.  Clarified power-off behavior for multi-core power domains. "

group d:0xC05001C4++0x03
    line.long 0x00 "SHADER_PWROFF_HI,SHADER_PWROFF_HI"
        hexmask.long 0x00 0.--31. 1. " SHADER_PWROFF_HI          ,   Requests that shader cores are to be powered off. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED . Power domains may contain multiple cores. In this case, a power domain must not be powered off until all cores within that domain are marked as powered off.        A core will therefore never be powered off 'implicitly' by powering down another core, but it may be kept powered if it shares a power domain with another active core.        It is therefore necessary to know the relationship between cores and power domains to determine the most appropriate set of cores to power down.  The relationship of cores to power domains is implementation dependent.         It often depends not only on the GPU model, but also on the details of system integration, and may vary across different system designs from the same vendor.        Please refer to implementation notes for your system to determine the mapping of cores to power domains.  Clarified power-off behavior for multi-core power domains. "

group d:0xC05001D0++0x03
    line.long 0x00 "TILER_PWROFF_LO,TILER_PWROFF_LO"
        hexmask.long 0x00 0.--31. 1. " TILER_PWROFF_LO           ,   Requests that tiler units are to be powered off. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC05001D4++0x03
    line.long 0x00 "TILER_PWROFF_HI,TILER_PWROFF_HI"
        hexmask.long 0x00 0.--31. 1. " TILER_PWROFF_HI           ,   Requests that tiler units are to be powered off. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC05001E0++0x03
    line.long 0x00 "L2_PWROFF_LO,L2_PWROFF_LO"
        hexmask.long 0x00 0.--31. 1. " L2_PWROFF_LO              ,   Requests that level 2 caches are to be powered off. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC05001E4++0x03
    line.long 0x00 "L2_PWROFF_HI,L2_PWROFF_HI"
        hexmask.long 0x00 0.--31. 1. " L2_PWROFF_HI              ,   Requests that level 2 caches are to be powered off. This register should only be written when all previous power transitions have been completed, otherwise results are  UNDEFINED ."

group d:0xC0500200++0x03
    line.long 0x00 "SHADER_PWRTRANS_LO,SHADER_PWRTRANS_LO"
        hexmask.long 0x00 0.--31. 1. " SHADER_PWRTRANS_LO        ,   Indicates which shader cores are currently changing power state. "

group d:0xC0500204++0x03
    line.long 0x00 "SHADER_PWRTRANS_HI,SHADER_PWRTRANS_HI"
        hexmask.long 0x00 0.--31. 1. " SHADER_PWRTRANS_HI        ,   Indicates which shader cores are currently changing power state. "

group d:0xC0500210++0x03
    line.long 0x00 "TILER_PWRTRANS_LO,TILER_PWRTRANS_LO"
        hexmask.long 0x00 0.--31. 1. " TILER_PWRTRANS_LO         ,   Indicates which tiler units are currently changing power state. "

group d:0xC0500214++0x03
    line.long 0x00 "TILER_PWRTRANS_HI,TILER_PWRTRANS_HI"
        hexmask.long 0x00 0.--31. 1. " TILER_PWRTRANS_HI         ,   Indicates which tiler units are currently changing power state. "

group d:0xC0500220++0x03
    line.long 0x00 "L2_PWRTRANS_LO,L2_PWRTRANS_LO"
        hexmask.long 0x00 0.--31. 1. " L2_PWRTRANS_LO            ,   Indicates which level 2 caches are currently changing power state. "

group d:0xC0500224++0x03
    line.long 0x00 "L2_PWRTRANS_HI,L2_PWRTRANS_HI"
        hexmask.long 0x00 0.--31. 1. " L2_PWRTRANS_HI            ,   Indicates which level 2 caches are currently changing power state. "

group d:0xC0500240++0x03
    line.long 0x00 "SHADER_PWRACTIVE_LO,SHADER_PWRACTIVE_LO"
        hexmask.long 0x00 0.--31. 1. " SHADER_PWRACTIVE_LO       ,   Indicates which shader cores are currently active and processing data. "

group d:0xC0500244++0x03
    line.long 0x00 "SHADER_PWRACTIVE_HI,SHADER_PWRACTIVE_HI"
        hexmask.long 0x00 0.--31. 1. " SHADER_PWRACTIVE_HI       ,   Indicates which shader cores are currently active and processing data. "

group d:0xC0500250++0x03
    line.long 0x00 "TILER_PWRACTIVE_LO,TILER_PWRACTIVE_LO"
        hexmask.long 0x00 0.--31. 1. " TILER_PWRACTIVE_LO        ,   Indicates which tiler units are currently active and processing data. "

group d:0xC0500254++0x03
    line.long 0x00 "TILER_PWRACTIVE_HI,TILER_PWRACTIVE_HI"
        hexmask.long 0x00 0.--31. 1. " TILER_PWRACTIVE_HI        ,   Indicates which tiler units are currently active and processing data. "

group d:0xC0500260++0x03
    line.long 0x00 "L2_PWRACTIVE_LO,L2_PWRACTIVE_LO"
        hexmask.long 0x00 0.--31. 1. " L2_PWRACTIVE_LO           ,   Indicates which level 2 cache units are currently active and processing data. "

group d:0xC0500264++0x03
    line.long 0x00 "L2_PWRACTIVE_HI,L2_PWRACTIVE_HI"
        hexmask.long 0x00 0.--31. 1. " L2_PWRACTIVE_HI           ,   Indicates which level 2 cache units are currently active and processing data. "

group d:0xC0500300++0x03
    line.long 0x00 "COHERENCY_FEATURES,   The Bifrost GPUs may support multiple coherency protocols. This register contains one boolean value for each protocol supported. At least one coherency protocol must be supported.  Changed for MIDHARC-184 "
        hexmask.long 0x00 2.--30. 1. " Res72                     ,Res72"
        bitfld.long 0x00 31. "                                      no_coherency           ,   This bit is reserved to give a guaranteed zero that can be used to disable coherency.  Reserved a bit for 'no coherency' protocol in COHERENCY_FEATURES. " "0,1"
        bitfld.long 0x00 0. "                                             ACE_LITE             ,ACE_LITE" "false,true"
        bitfld.long 0x00 1. "                                         ACE                       ,ACE" "false,true"

group d:0xC0500304++0x03
    line.long 0x00 "COHERENCY_ENABLE,   This register contains an index indicating which coherency protocol should be enabled. The index values correspond to the bit numbers in the  COHERENCY_FEATURES register. At least one coherency protocol must be supported. If the indexed bit is 0, then coherency is disabled. The  no_coherency bit is reserved to give a guaranteed zero that can always be used to disable coherency. Changed for MIDHARC-184  Added behavior for 'no coherency' protocol in COHERENCY_ENABLE. "
        hexmask.long 0x00 0.--31. 1. " L2_CACHE_PROTOCOL_SELECT  ,L2_CACHE_PROTOCOL_SELECT"

group d:0xC0500400++0x03
    line.long 0x00 "GPU_USER_IN_0,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_0             ,GPU_USER_IN_0"

group d:0xC0500404++0x03
    line.long 0x00 "GPU_USER_IN_1,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_1             ,GPU_USER_IN_1"

group d:0xC0500408++0x03
    line.long 0x00 "GPU_USER_IN_2,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_2             ,GPU_USER_IN_2"

group d:0xC050040C++0x03
    line.long 0x00 "GPU_USER_IN_3,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_3             ,GPU_USER_IN_3"

group d:0xC0500410++0x03
    line.long 0x00 "GPU_USER_IN_4,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_4             ,GPU_USER_IN_4"

group d:0xC0500414++0x03
    line.long 0x00 "GPU_USER_IN_5,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_5             ,GPU_USER_IN_5"

group d:0xC0500418++0x03
    line.long 0x00 "GPU_USER_IN_6,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_6             ,GPU_USER_IN_6"

group d:0xC050041C++0x03
    line.long 0x00 "GPU_USER_IN_7,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_7             ,GPU_USER_IN_7"

group d:0xC0500420++0x03
    line.long 0x00 "GPU_USER_IN_8,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_8             ,GPU_USER_IN_8"

group d:0xC0500424++0x03
    line.long 0x00 "GPU_USER_IN_9,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_9             ,GPU_USER_IN_9"

group d:0xC0500428++0x03
    line.long 0x00 "GPU_USER_IN_10,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_10            ,GPU_USER_IN_10"

group d:0xC050042C++0x03
    line.long 0x00 "GPU_USER_IN_11,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_11            ,GPU_USER_IN_11"

group d:0xC0500430++0x03
    line.long 0x00 "GPU_USER_IN_12,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_12            ,GPU_USER_IN_12"

group d:0xC0500434++0x03
    line.long 0x00 "GPU_USER_IN_13,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_13            ,GPU_USER_IN_13"

group d:0xC0500438++0x03
    line.long 0x00 "GPU_USER_IN_14,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_14            ,GPU_USER_IN_14"

group d:0xC050043C++0x03
    line.long 0x00 "GPU_USER_IN_15,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_15            ,GPU_USER_IN_15"

group d:0xC0500440++0x03
    line.long 0x00 "GPU_USER_IN_16,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_16            ,GPU_USER_IN_16"

group d:0xC0500444++0x03
    line.long 0x00 "GPU_USER_IN_17,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_17            ,GPU_USER_IN_17"

group d:0xC0500448++0x03
    line.long 0x00 "GPU_USER_IN_18,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_18            ,GPU_USER_IN_18"

group d:0xC050044C++0x03
    line.long 0x00 "GPU_USER_IN_19,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_19            ,GPU_USER_IN_19"

group d:0xC0500450++0x03
    line.long 0x00 "GPU_USER_IN_20,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_20            ,GPU_USER_IN_20"

group d:0xC0500454++0x03
    line.long 0x00 "GPU_USER_IN_21,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_21            ,GPU_USER_IN_21"

group d:0xC0500458++0x03
    line.long 0x00 "GPU_USER_IN_22,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_22            ,GPU_USER_IN_22"

group d:0xC050045C++0x03
    line.long 0x00 "GPU_USER_IN_23,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_23            ,GPU_USER_IN_23"

group d:0xC0500460++0x03
    line.long 0x00 "GPU_USER_IN_24,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_24            ,GPU_USER_IN_24"

group d:0xC0500464++0x03
    line.long 0x00 "GPU_USER_IN_25,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_25            ,GPU_USER_IN_25"

group d:0xC0500468++0x03
    line.long 0x00 "GPU_USER_IN_26,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_26            ,GPU_USER_IN_26"

group d:0xC050046C++0x03
    line.long 0x00 "GPU_USER_IN_27,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_27            ,GPU_USER_IN_27"

group d:0xC0500470++0x03
    line.long 0x00 "GPU_USER_IN_28,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_28            ,GPU_USER_IN_28"

group d:0xC0500474++0x03
    line.long 0x00 "GPU_USER_IN_29,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_29            ,GPU_USER_IN_29"

group d:0xC0500478++0x03
    line.long 0x00 "GPU_USER_IN_30,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_30            ,GPU_USER_IN_30"

group d:0xC050047C++0x03
    line.long 0x00 "GPU_USER_IN_31,   The Bifrost GPUs all allow vendors to specify up to 1024 user input signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_IN signals are connected to the GPU_USER_IN  n registers. The signals and registers are numbered consecutively from zero, and signal USER_IN[i] will appear at bit position [i % 32] in register GPU_USER_IN[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_IN_31            ,GPU_USER_IN_31"

group d:0xC0500500++0x03
    line.long 0x00 "GPU_USER_OUT_0,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_0            ,GPU_USER_OUT_0"

group d:0xC0500504++0x03
    line.long 0x00 "GPU_USER_OUT_1,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_1            ,GPU_USER_OUT_1"

group d:0xC0500508++0x03
    line.long 0x00 "GPU_USER_OUT_2,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_2            ,GPU_USER_OUT_2"

group d:0xC050050C++0x03
    line.long 0x00 "GPU_USER_OUT_3,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_3            ,GPU_USER_OUT_3"

group d:0xC0500510++0x03
    line.long 0x00 "GPU_USER_OUT_4,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_4            ,GPU_USER_OUT_4"

group d:0xC0500514++0x03
    line.long 0x00 "GPU_USER_OUT_5,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_5            ,GPU_USER_OUT_5"

group d:0xC0500518++0x03
    line.long 0x00 "GPU_USER_OUT_6,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_6            ,GPU_USER_OUT_6"

group d:0xC050051C++0x03
    line.long 0x00 "GPU_USER_OUT_7,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_7            ,GPU_USER_OUT_7"

group d:0xC0500520++0x03
    line.long 0x00 "GPU_USER_OUT_8,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_8            ,GPU_USER_OUT_8"

group d:0xC0500524++0x03
    line.long 0x00 "GPU_USER_OUT_9,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_9            ,GPU_USER_OUT_9"

group d:0xC0500528++0x03
    line.long 0x00 "GPU_USER_OUT_10,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_10           ,GPU_USER_OUT_10"

group d:0xC050052C++0x03
    line.long 0x00 "GPU_USER_OUT_11,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_11           ,GPU_USER_OUT_11"

group d:0xC0500530++0x03
    line.long 0x00 "GPU_USER_OUT_12,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_12           ,GPU_USER_OUT_12"

group d:0xC0500534++0x03
    line.long 0x00 "GPU_USER_OUT_13,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_13           ,GPU_USER_OUT_13"

group d:0xC0500538++0x03
    line.long 0x00 "GPU_USER_OUT_14,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_14           ,GPU_USER_OUT_14"

group d:0xC050053C++0x03
    line.long 0x00 "GPU_USER_OUT_15,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_15           ,GPU_USER_OUT_15"

group d:0xC0500540++0x03
    line.long 0x00 "GPU_USER_OUT_16,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_16           ,GPU_USER_OUT_16"

group d:0xC0500544++0x03
    line.long 0x00 "GPU_USER_OUT_17,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_17           ,GPU_USER_OUT_17"

group d:0xC0500548++0x03
    line.long 0x00 "GPU_USER_OUT_18,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_18           ,GPU_USER_OUT_18"

group d:0xC050054C++0x03
    line.long 0x00 "GPU_USER_OUT_19,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_19           ,GPU_USER_OUT_19"

group d:0xC0500550++0x03
    line.long 0x00 "GPU_USER_OUT_20,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_20           ,GPU_USER_OUT_20"

group d:0xC0500554++0x03
    line.long 0x00 "GPU_USER_OUT_21,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_21           ,GPU_USER_OUT_21"

group d:0xC0500558++0x03
    line.long 0x00 "GPU_USER_OUT_22,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_22           ,GPU_USER_OUT_22"

group d:0xC050055C++0x03
    line.long 0x00 "GPU_USER_OUT_23,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_23           ,GPU_USER_OUT_23"

group d:0xC0500560++0x03
    line.long 0x00 "GPU_USER_OUT_24,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_24           ,GPU_USER_OUT_24"

group d:0xC0500564++0x03
    line.long 0x00 "GPU_USER_OUT_25,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_25           ,GPU_USER_OUT_25"

group d:0xC0500568++0x03
    line.long 0x00 "GPU_USER_OUT_26,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_26           ,GPU_USER_OUT_26"

group d:0xC050056C++0x03
    line.long 0x00 "GPU_USER_OUT_27,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_27           ,GPU_USER_OUT_27"

group d:0xC0500570++0x03
    line.long 0x00 "GPU_USER_OUT_28,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_28           ,GPU_USER_OUT_28"

group d:0xC0500574++0x03
    line.long 0x00 "GPU_USER_OUT_29,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_29           ,GPU_USER_OUT_29"

group d:0xC0500578++0x03
    line.long 0x00 "GPU_USER_OUT_30,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_30           ,GPU_USER_OUT_30"

group d:0xC050057C++0x03
    line.long 0x00 "GPU_USER_OUT_31,   The Bifrost GPUs all allow vendors to specify up to 1024 user output signals. The meaning of these signals is not architecturally defined, and is entirely down to the vendor. Typical uses include sending additional information to power controllers or display controllers.  These USER_OUT signals are connected to the GPU_USER_OUT  n registers. The signals and registers are numbered consecutively from zero, and signal USER_OUT[i] will appear at bit position [i % 32] in register GPU_USER_OUT[i/32]."
        hexmask.long 0x00 0.--31. 1. " GPU_USER_OUT_31           ,GPU_USER_OUT_31"

width 19.

group d:0xC0501000++0x03
    line.long 0x00 "JOB_IRQ_RAWSTAT,   This register contains the raw unmasked interrupt status for job management.  Writing a 1 to a bit in this register will force that bit on. Writing a zero to a bit will have no effect. Use the JOB_IRQ_CLEAR register to clear interrupts. Changes to bits corresponding to job slots which are not physically present may be ignored.  See  ExceptionStatus for information on exception types and locations of additional data. JOB_DONE interrupts are generated for any job chain that completes with an exception type that indicates no fault. JOB_FAIL interrupts are generated for all other exception types, including SUSPEND."
        hexmask.long.word 0x00 0.--15. 1. " JOB_DONE         ,JOB_DONE"
        hexmask.long.word 0x00 16.--31. 1. "      JOB_FAIL        ,JOB_FAIL"

group d:0xC0501004++0x03
    line.long 0x00 "JOB_IRQ_CLEAR,   This register has the same layout as JOB_IRQ_RAWSTAT. Write a one to a bit in this register to clear the corresponding bit in JOB_IRQ_RAWSTAT. This also atomically takes a snapshot of the corresponding job slots state in the corresponding bits of JOB_IRQ_JS_STATE. "
        hexmask.long.word 0x00 0.--15. 1. " JOB_DONE         ,JOB_DONE"
        hexmask.long.word 0x00 16.--31. 1. "      JOB_FAIL        ,JOB_FAIL"

group d:0xC0501008++0x03
    line.long 0x00 "JOB_IRQ_MASK,   This register has the same layout as JOB_IRQ_RAWSTAT. Set each bit in this to one to enable the corresponding interrupt source, and to zero to disable it. "
        hexmask.long.word 0x00 0.--15. 1. " JOB_DONE         ,JOB_DONE"
        hexmask.long.word 0x00 16.--31. 1. "      JOB_FAIL        ,JOB_FAIL"

group d:0xC050100C++0x03
    line.long 0x00 "JOB_IRQ_STATUS,   This register has the same layout as JOB_IRQ_RAWSTAT. This register contains the result of anding together JOB_IRQ_RAWSTAT and JOB_IRQ_MASK. If any bits in this register are set, and the JOB_IRQ_THROTTLE counter is zero, then the external job control interrupt line is asserted, signaling an interrupt request to the CPU. "
        hexmask.long.word 0x00 0.--15. 1. " JOB_DONE         ,JOB_DONE"
        hexmask.long.word 0x00 16.--31. 1. "      JOB_FAIL        ,JOB_FAIL"

group d:0xC0501010++0x03
    line.long 0x00 "JOB_IRQ_JS_STATE,   This register contains an instantaneous snapshot of the state of the job chains, and is updated atomically in the same clock cycle as the interrupt flags are cleared (using JOB_IRQ_CLEAR).  If either bit JOB_ACTIVE[n] or JOB_NEXT_ACTIVE[n] is set in the value written to JOB_IRQ_CLEAR, then job slot  n is sampled on the same clock cycle, and both bits JOB_ACTIVE[n] and JOB_NEXT_ACTIVE[n] are updated in this register."
        hexmask.long.word 0x00 0.--15. 1. " JOB_ACTIVE       ,JOB_ACTIVE"
        hexmask.long.word 0x00 16.--31. 1. "      JOB_NEXT_ACTIVE ,JOB_NEXT_ACTIVE"

group d:0xC0501014++0x03
    line.long 0x00 "JOB_IRQ_THROTTLE,   This register is used to suppress Job Done interrupts for a set amount of time. This allows software to throttle the interrupt load that the rest of the system is exposed to. "
        hexmask.long 0x00 0.--31. 1. " JOB_IRQ_THROTTLE ,   Writing a value to the register sets the value of a counter, which continuously counts down at the GPU clock frequency. Reading this register will return the current value of the counter.  While the counter is non-zero, no Job Done interrupts are generated. In this state, the GPU is considered to be active for power management purposes, so that the final interrupt will always be generated correctly, even if the core is being powered down.  The counter stops once it has counted down to zero, and must be reset by the driver. This is commonly done as part of the interrupt service routine. "

group d:0xC0501020++0x03
    line.long 0x00 "EVENT_IRQ_RAWSTAT,   This register contains the raw unmasked interrupt status for job event management.  Writing a 1 to a bit in this register will force that bit on. Writing a zero to a bit will have no effect. Use the EVENT_IRQ_CLEAR register to clear interrupts. Changes to bits corresponding to job slots which are not physically present may be ignored.  This is a separate interrupt from job status interrupts, and is triggered by use of  DOORBELL event-generating instructions in the shaders. Added registers for handling job events and their corresponding interrupts. "
        hexmask.long.word 0x00 16.--31. 1. " Res73            ,Res73"
        hexmask.long.word 0x00 0.--15. 1. "      EVENT_DONE      ,EVENT_DONE"

group d:0xC0501024++0x03
    line.long 0x00 "EVENT_IRQ_CLEAR,   This register has the same layout as EVENT_IRQ_RAWSTAT. Write a one to a bit in this register to clear the corresponding bit in EVENT_IRQ_RAWSTAT. "
        hexmask.long.word 0x00 16.--31. 1. " Res74            ,Res74"
        hexmask.long.word 0x00 0.--15. 1. "      EVENT_DONE      ,EVENT_DONE"

group d:0xC0501028++0x03
    line.long 0x00 "EVENT_IRQ_MASK,   This register has the same layout as EVENT_IRQ_RAWSTAT. Set each bit in this to one to enable the corresponding interrupt source, and to zero to disable it. "
        hexmask.long.word 0x00 16.--31. 1. " Res75            ,Res75"
        hexmask.long.word 0x00 0.--15. 1. "      EVENT_DONE      ,EVENT_DONE"

group d:0xC050102C++0x03
    line.long 0x00 "EVENT_IRQ_STATUS,   This register has the same layout as EVENT_IRQ_RAWSTAT. This register contains the result of anding together EVENT_IRQ_RAWSTAT and EVENT_IRQ_MASK. If any bits in this register are set, and the JOB_IRQ_THROTTLE counter is zero, then the external job control interrupt line is asserted, signaling an interrupt request to the CPU. "
        hexmask.long.word 0x00 16.--31. 1. " Res76            ,Res76"
        hexmask.long.word 0x00 0.--15. 1. "      EVENT_DONE      ,EVENT_DONE"

width 22.

group d:0xC0501800++0x03
    line.long 0x00 "JS0_HEAD_LO,   These registers exist for each supported job slot, with the prefix JS  n . To start a job chain, write the address to the first job descriptor into the JS  n _HEAD_NEXT register and write a START command to the JS n _COMMAND_NEXT register. When read, this register reflects the current position in the job chain. When the Job Manager has finished issuing tasks for a job, it will go on to the next job in the job chain, and update JS  n _HEAD. A job will disappear from JS  n _HEAD before it has finished processing all its tasks. See JS n _TAIL for how to discover this. Jobs newer than JS  n _HEAD may have been prefetched from memory, but will not yet have started processing. After an error, JS  n _HEAD contains the address of the first job (chronologically) that failed. The status registers contain the state of this job. If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS0HEAD_LO             ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501804++0x03
    line.long 0x00 "JS0_HEAD_HI,   These registers exist for each supported job slot, with the prefix JS  n . To start a job chain, write the address to the first job descriptor into the JS  n _HEAD_NEXT register and write a START command to the JS n _COMMAND_NEXT register. When read, this register reflects the current position in the job chain. When the Job Manager has finished issuing tasks for a job, it will go on to the next job in the job chain, and update JS  n _HEAD. A job will disappear from JS  n _HEAD before it has finished processing all its tasks. See JS n _TAIL for how to discover this. Jobs newer than JS  n _HEAD may have been prefetched from memory, but will not yet have started processing. After an error, JS  n _HEAD contains the address of the first job (chronologically) that failed. The status registers contain the state of this job. If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS0HEAD_HI             ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501808++0x03
    line.long 0x00 "JS0_TAIL_LO,   If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS0TAIL_LO             ,   This register contains the address of the oldest job that has finished issuing tasks, but is still running. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register. All the jobs in a job chain from JS  n _TAIL to JS n _HEAD are in some way active in the GPU. Jobs older than JS n _TAIL are fully completed. Note that the value in the JS  n _TAIL register is updated when a new job starts. Therefore, this value is only valid while the JS n _STATUS register has the value ACTIVE. After an error, JS  n _TAIL contains the address of the first job in the chain that is not known to be successfully complete. Other jobs after this point may have completed successfully, but all jobs prior to this point are guaranteed have completed.       In order to simplfy implementation of this feature, the position reported in JS n _TAIL is allowed to be conservative. However, scanning from this point forward in the chain will always be sufficient to identify all failing jobs."

group d:0xC050180C++0x03
    line.long 0x00 "JS0_TAIL_HI,   If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS0TAIL_HI             ,   This register contains the address of the oldest job that has finished issuing tasks, but is still running. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register. All the jobs in a job chain from JS  n _TAIL to JS n _HEAD are in some way active in the GPU. Jobs older than JS n _TAIL are fully completed. Note that the value in the JS  n _TAIL register is updated when a new job starts. Therefore, this value is only valid while the JS n _STATUS register has the value ACTIVE. After an error, JS  n _TAIL contains the address of the first job in the chain that is not known to be successfully complete. Other jobs after this point may have completed successfully, but all jobs prior to this point are guaranteed have completed.       In order to simplfy implementation of this feature, the position reported in JS n _TAIL is allowed to be conservative. However, scanning from this point forward in the chain will always be sufficient to identify all failing jobs."

group d:0xC0501810++0x03
    line.long 0x00 "JS0_AFFINITY_LO,   This register contains the current core affinity mask for this job slot. Only cores covered by the affinity mask are eligible for running tasks on. The mask is anded with the *_READY masks, and the resulting ones are the cores that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains.See also JS  n _XAFFINITY"
        hexmask.long 0x00 0.--31. 1. " JS0AFFINITY_LO         ,JS0AFFINITY_LO"

group d:0xC0501814++0x03
    line.long 0x00 "JS0_AFFINITY_HI,   This register contains the current core affinity mask for this job slot. Only cores covered by the affinity mask are eligible for running tasks on. The mask is anded with the *_READY masks, and the resulting ones are the cores that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains.See also JS  n _XAFFINITY"
        hexmask.long 0x00 0.--31. 1. " JS0AFFINITY_HI         ,JS0AFFINITY_HI"

group d:0xC0501818++0x03
    line.long 0x00 "JS0_CONFIG,   The job slot configuration register contains various configuration options for the jobs running in this job slot. "
        bitfld.long 0x00 4.--7. " Res77                  ,Res77" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.word 0x00 20.--31. 1. "        Res78                        ,Res78"
        bitfld.long 0x00 0.--3. "                                 ADDRESS_SPACE ,   This is the ID of the address space to use for execution of all the jobs in this job chain.       Address space configuration values are read from the AS  n registers.       Specifying an address space that is not supported (i.e. the corresponding bit in AS_PRESENT is 0) may result in UNDEFINED behavior." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 11. "                                   JOB_CHAIN_FLAG ,   The JOB_CHAIN_FLAG is set and read by software, and is used to disambiguate short-running job chains. It has no effect on the execution of a job, but is transferred intact from the JS  n _CONFIG_NEXT register to the JS n _CONFIG register when a job starts." "0,1"
        textline "                                "
        bitfld.long 0x00 16.--19. "THREAD_PRI             ,   The thread priority is ordered so that high values will cause threads to be issued faster. Priority values are relative to the other jobs running  if no other jobs are issuing threads, this job will never be throttled even with low priorities.  How the priority values affect issue rates from different slots is implementation dependent. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--9. "        START_FLUSH                  ,   Before the job chain is started, the selected action is applied to all caches except the tiler cache.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         Any non-zero value in this field will cause both a clean  and an invalidate for the read-write caches.         If the value is 3, then the read-only caches are also invalidated, as specified.         The flush command goes to all GPU cores enabled in the affinity mask, and the L2 cache." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 12.--13. "  END_FLUSH     ,   After the job chain is finished, the selected action is applied to all caches including the tiler cache. This happens when the job chain ends with a success code, or a fault code other than JOB_CONFIG_FAULT or JOB_POWER_FAULT. In the case of JOB_CONFIG_FAULT and JOB_POWER_FAULT, the job chain could not even start and so no cache flush on end takes place.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         The flush command goes only to the L2 cache. The tiler cache is not affected.         Any non-zero value in this field will cause both a clean  and an invalidate." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 10. "  START_MMU      ,START_MMU" "false:  No MMU actions ,true"
        textline "                                "
        bitfld.long 0x00 14. "ENABLE_FLUSH_REDUCTION ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a suppressable flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed. Otherwise, the flush  may be suppressed. Not all flushes can be suppressed, and not all suppressable flushes may be suppressed in any particular hardware implementation. In particular:    A CLEAN_INVALIDATE operation can replace a CLEAN, but not the other way around.  A CLEAN_INVALIDATE operation can be suppressed at the start of a job chain.  A CLEAN or CLEAN_INVALIDATE operation at the end of a job chain cannot be suppressed in the general case.  If software can guarantee that it will not read the result of a job chain until another job chain has been completed, then this is a case where the CLEAN or CLEAN_INVALIDATE operation at the end of a job chain could be suppressed. It is, however, simpler for software to signal this guarantee by simply not enabling the end-of-chain cache flush at all.  Explicit cache flush jobs are assumed to have been placed into the job chain for a reason, and are therefore not suppressed.  Clarified cache flush reduction  Added cache flush reduction " "false,true"
        bitfld.long 0x00 15. "     DISABLE_DESCRIPTOR_WRITEBACK ,   Normally, the status of each job in the job chain is written back as it is completed. This flag allows software to suppress that mechanism in cases where it is not required. Regardless of the setting of this flag, a job slot's  STATUS register is always updated on completion of its job chain. One of the reasons for writing back the status to the job descriptors is to guard against infinite loops in job chains. If this flag is set, then that protection is disabled and additional steps should be taken to detect and mitigate infinite loops.  Added  DISABLE_DESCRIPTOR_WRITEBACK flag to job slot CONFIG register." "false,true"

group d:0xC050181C++0x03
    line.long 0x00 "JS0_XAFFINITY,   Additional affinity information for job slot  n exists in this register. Only resources covered by the affinity mask are eligible for receiving commands. The mask is anded with the appropriate bits from the TILER_PRESENT and L2_PRESENT masks, and the resulting ones are the resources that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains. "
        hexmask.long.byte 0x00 1.--7. 1. " Res79                  ,Res79"
        bitfld.long 0x00 0. "        XAFFINITY_ENABLE             ,XAFFINITY_ENABLE" "false,true:  This register is enabled. "
        hexmask.long.byte 0x00 8.--15. 1. "    TILER_ENABLE  ,   This field selects which tilers receive commands such as cache flushes and tiler jobs. "
        hexmask.long.word 0x00 16.--31. 1. "                                   CACHE_ENABLE   ,   This field selects which level 2 caches receive commands such as cache flushes and tiler jobs. "

group d:0xC0501820++0x03
    line.long 0x00 "JS0_COMMAND,   Writing values to this register will control the job currently running in job slot  n . When the Job Manager encounters the end of a job chain, an interrupt is generated and (if appropriate) the contents of the next registers are transferred to the current registers, allowing immediate execution of a new job chain.  Jobs can be started only by writing to the JS  n _COMMAND_NEXT register, not this register, as this process depends on reliable transfer of the other values describing the job. A soft stop requests that no more tasks are issued for a job, and once all running tasks are finished, the job state is written to memory and the job suspended. It is possible to recover from this state and continue the job.  A hard stop simply aborts all running tasks for a job. No attempt is made to finish, write partial results, or save state. It will not be possible to resume a job after a hard stop, although it may be possible to restart it from scratch if it does not write to its own inputs. To do this, the driver must set the job status to STOPPED and also set the restart index to 0.  The conditional versions of SOFT_STOP and HARD_STOP are designed to eliminate race conditions when checking the JOB_CHAIN_FLAG, which is in the JS  n _CONFIG register. The stop command is only issued if the current state of the flag matches the value in the command name. If it does not match, then the command is treated like a NOP and nothing happens."
        hexmask.long 0x00 0.--31. 1. " JS0COMMAND             ,   Added SUSPEND and RESUME commands to job chain  COMMAND register."

group d:0xC0501824++0x03
    line.long 0x00 "JS0_STATUS,   This register indicates the status of the job chain running in this job slot.  During typical operation, the status starts in state  NOT_STARTED , then switches to ACTIVE during job chain execution, and on completion the status will change to either DONE for successful execution, or another exception code if an error occurred. Corrected description of job slot STATUS register  If the GPU is in protected mode, this register will read as zero. "
        hexmask.long.tbyte 0x00 8.--31. 1. " Res80                  ,Res80"
        hexmask.long.byte 0x00 0.--7. 1. "    EXCEPTION_TYPE               ,   Added new MMU exception types.  Changed INTERRUPTED exception type to SUSPENDED.  Added exception types for new events EUREKA and KABOOM.  Removed aliases for OK - used to also be called IDLE and NOT_STARTED.  Documented that a KABOOM instruction will cause other jobs to hard-stop.  Removed OUT_OF_MEMORY_AFBC error as it can only occur with non-sparse allocation (now removed).  Removed INSTR_TYPE_MISMATCH, INSTR_OPERAND_FAULT, INSTR_TLS_FAULT, INSTR_ALIGN_FAULT; added IMPRECISE_FAULT (0x5B).  Split SHAREABILITY_FAULT into GPU_SHAREABILITY_FAULT, SYSTEM_SHAREABILITY_FAULT and GPU_CACHEABILITY_FAULT. "

group d:0xC0501830++0x03
    line.long 0x00 "JS0_FLUSH_ID,   This register contains the current cache flush ID for this job slot. "
        hexmask.long 0x00 0.--31. 1. " JS0FLUSH_ID            ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed.  Care must be taken in the overflow case. If the software setting up the ID detects that an overflow may occur, the job chain should be tagged with the maximum value of the  LATEST_FLUSH register. This ensures that flushes are correctly performed, at the possible cost of a few redundant flushes. Added cache flush reduction "

group d:0xC0501834++0x03
    line.long 0x00 "JS0_EVENT_0,   This register is used to accumulate events for job chains where the job chain disambiguation bit is 0.  Added event registers to job slots. "
        hexmask.long 0x00 0.--31. 1. " JS0EVENT_0             ,JS0EVENT_0"

group d:0xC0501838++0x03
    line.long 0x00 "JS0_EVENT_1,   This register is used to accumulate events for job chains where the job chain disambiguation bit is 1. "
        hexmask.long 0x00 0.--31. 1. " JS0EVENT_1             ,JS0EVENT_1"

group d:0xC050183C++0x03
    line.long 0x00 "JS0_EVENT_MASK,   This register is the current event mask. "
        hexmask.long 0x00 0.--31. 1. " JS0EVENT_MASK          ,JS0EVENT_MASK"

group d:0xC0501840++0x03
    line.long 0x00 "JS0_HEAD_NEXT_LO,   This register contains the value to be transferred into the JS  n _HEAD register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS0HEAD_NEXT_LO        ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501844++0x03
    line.long 0x00 "JS0_HEAD_NEXT_HI,   This register contains the value to be transferred into the JS  n _HEAD register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS0HEAD_NEXT_HI        ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501850++0x03
    line.long 0x00 "JS0_AFFINITY_NEXT_LO,   This register contains the value to be transferred into the JS  n _AFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS0AFFINITY_NEXT_LO    ,JS0AFFINITY_NEXT_LO"

group d:0xC0501854++0x03
    line.long 0x00 "JS0_AFFINITY_NEXT_HI,   This register contains the value to be transferred into the JS  n _AFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS0AFFINITY_NEXT_HI    ,JS0AFFINITY_NEXT_HI"

group d:0xC0501858++0x03
    line.long 0x00 "JS0_CONFIG_NEXT,   This register contains the value to be transferred into the JS  n _CONFIG register when the next job chain starts. See COMMAND_NEXT for details."
        bitfld.long 0x00 4.--7. " Res81                  ,Res81" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.word 0x00 20.--31. 1. "        Res82                        ,Res82"
        bitfld.long 0x00 0.--3. "                                 ADDRESS_SPACE ,   This is the ID of the address space to use for execution of all the jobs in this job chain.       Address space configuration values are read from the AS  n registers.       Specifying an address space that is not supported (i.e. the corresponding bit in AS_PRESENT is 0) may result in UNDEFINED behavior." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 11. "                                   JOB_CHAIN_FLAG ,   The JOB_CHAIN_FLAG is set and read by software, and is used to disambiguate short-running job chains. It has no effect on the execution of a job, but is transferred intact from the JS  n _CONFIG_NEXT register to the JS n _CONFIG register when a job starts." "0,1"
        textline "                                "
        bitfld.long 0x00 16.--19. "THREAD_PRI             ,   The thread priority is ordered so that high values will cause threads to be issued faster. Priority values are relative to the other jobs running  if no other jobs are issuing threads, this job will never be throttled even with low priorities.  How the priority values affect issue rates from different slots is implementation dependent. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--9. "        START_FLUSH                  ,   Before the job chain is started, the selected action is applied to all caches except the tiler cache.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         Any non-zero value in this field will cause both a clean  and an invalidate for the read-write caches.         If the value is 3, then the read-only caches are also invalidated, as specified.         The flush command goes to all GPU cores enabled in the affinity mask, and the L2 cache." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 12.--13. "  END_FLUSH     ,   After the job chain is finished, the selected action is applied to all caches including the tiler cache. This happens when the job chain ends with a success code, or a fault code other than JOB_CONFIG_FAULT or JOB_POWER_FAULT. In the case of JOB_CONFIG_FAULT and JOB_POWER_FAULT, the job chain could not even start and so no cache flush on end takes place.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         The flush command goes only to the L2 cache. The tiler cache is not affected.         Any non-zero value in this field will cause both a clean  and an invalidate." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 10. "  START_MMU      ,START_MMU" "false:  No MMU actions ,true"
        textline "                                "
        bitfld.long 0x00 14. "ENABLE_FLUSH_REDUCTION ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a suppressable flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed. Otherwise, the flush  may be suppressed. Not all flushes can be suppressed, and not all suppressable flushes may be suppressed in any particular hardware implementation. In particular:    A CLEAN_INVALIDATE operation can replace a CLEAN, but not the other way around.  A CLEAN_INVALIDATE operation can be suppressed at the start of a job chain.  A CLEAN or CLEAN_INVALIDATE operation at the end of a job chain cannot be suppressed in the general case.  If software can guarantee that it will not read the result of a job chain until another job chain has been completed, then this is a case where the CLEAN or CLEAN_INVALIDATE operation at the end of a job chain could be suppressed. It is, however, simpler for software to signal this guarantee by simply not enabling the end-of-chain cache flush at all.  Explicit cache flush jobs are assumed to have been placed into the job chain for a reason, and are therefore not suppressed.  Clarified cache flush reduction  Added cache flush reduction " "false,true"
        bitfld.long 0x00 15. "     DISABLE_DESCRIPTOR_WRITEBACK ,   Normally, the status of each job in the job chain is written back as it is completed. This flag allows software to suppress that mechanism in cases where it is not required. Regardless of the setting of this flag, a job slot's  STATUS register is always updated on completion of its job chain. One of the reasons for writing back the status to the job descriptors is to guard against infinite loops in job chains. If this flag is set, then that protection is disabled and additional steps should be taken to detect and mitigate infinite loops.  Added  DISABLE_DESCRIPTOR_WRITEBACK flag to job slot CONFIG register." "false,true"

group d:0xC050185C++0x03
    line.long 0x00 "JS0_XAFFINITY_NEXT,   This register contains the value to be transferred into the JS  n _XAFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long.byte 0x00 1.--7. 1. " Res83                  ,Res83"
        bitfld.long 0x00 0. "        XAFFINITY_ENABLE             ,XAFFINITY_ENABLE" "false,true:  This register is enabled. "
        hexmask.long.byte 0x00 8.--15. 1. "    TILER_ENABLE  ,   This field selects which tilers receive commands such as cache flushes and tiler jobs. "
        hexmask.long.word 0x00 16.--31. 1. "                                   CACHE_ENABLE   ,   This field selects which level 2 caches receive commands such as cache flushes and tiler jobs. "

group d:0xC0501860++0x03
    line.long 0x00 "JS0_COMMAND_NEXT,   When the current job chain is completed, if there are no unacknowledged errors from the previous job chain, and this register is not set to NOP,      then the contents of the *_NEXT registers are transferred to the corresponding current * registers. This allows software to construct job chains one ahead and maintain throughput.  When the values are transferred, the JS  n _COMMAND_NEXT register is cleared, indicating a NOP. The register is then ready to accept a new command. The JS n _HEAD_NEXT register is also cleared at the same time. The state of the current job can be determined using JS n _STATUS. In order to prevent new chains being transferred in a half-completed state, data is transferred only when a START command is present in the JS  n _COMMAND_NEXT register. Therefore, software should initialize the other _NEXT registers first, and only write a START command to the JS n _COMMAND_NEXT register when the data for the next job is complete. If there is no job running in slot n when START is written to JS  n _COMMAND_NEXT, the next data is transferred immediately.      If the next command value is anything except START, nothing happens. To stop jobs, write STOP commands to the JS  n _COMMAND register instead. If any status is returned from a job in the previous job chain other than DONE, the JOB_FAIL_  n bit for this job chain is set in the JOB_IRQ_RAWSTAT register, and the next job chain is not started. This allows software to retrieve the current register values. Software must indicate that it is ready to proceed by clearing the error interrupt bit, at which point the next job chain may be started."
        hexmask.long 0x00 0.--31. 1. " JS0COMMAND_NEXT        ,   Added SUSPEND and RESUME commands to job chain  COMMAND register."

group d:0xC0501870++0x03
    line.long 0x00 "JS0_FLUSH_ID_NEXT,   This register contains the value to be transferred into the JS  n _FLUSH_ID register when the next job chain starts. See FLUSH_ID for details."
        hexmask.long 0x00 0.--31. 1. " JS0FLUSH_ID_NEXT       ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed.  Care must be taken in the overflow case. If the software setting up the ID detects that an overflow may occur, the job chain should be tagged with the maximum value of the  LATEST_FLUSH register. This ensures that flushes are correctly performed, at the possible cost of a few redundant flushes. Added cache flush reduction "

group d:0xC050187C++0x03
    line.long 0x00 "JS0_EVENT_MASK_NEXT,   This register contains the value to be transferred into the JS  n _EVENT_MASK register when the next job chain starts. See EVENT_MASK for details."
        hexmask.long 0x00 0.--31. 1. " JS0EVENT_MASK_NEXT     ,JS0EVENT_MASK_NEXT"

width 22.

group d:0xC0501880++0x03
    line.long 0x00 "JS1_HEAD_LO,   These registers exist for each supported job slot, with the prefix JS  n . To start a job chain, write the address to the first job descriptor into the JS  n _HEAD_NEXT register and write a START command to the JS n _COMMAND_NEXT register. When read, this register reflects the current position in the job chain. When the Job Manager has finished issuing tasks for a job, it will go on to the next job in the job chain, and update JS  n _HEAD. A job will disappear from JS  n _HEAD before it has finished processing all its tasks. See JS n _TAIL for how to discover this. Jobs newer than JS  n _HEAD may have been prefetched from memory, but will not yet have started processing. After an error, JS  n _HEAD contains the address of the first job (chronologically) that failed. The status registers contain the state of this job. If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS1HEAD_LO             ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501884++0x03
    line.long 0x00 "JS1_HEAD_HI,   These registers exist for each supported job slot, with the prefix JS  n . To start a job chain, write the address to the first job descriptor into the JS  n _HEAD_NEXT register and write a START command to the JS n _COMMAND_NEXT register. When read, this register reflects the current position in the job chain. When the Job Manager has finished issuing tasks for a job, it will go on to the next job in the job chain, and update JS  n _HEAD. A job will disappear from JS  n _HEAD before it has finished processing all its tasks. See JS n _TAIL for how to discover this. Jobs newer than JS  n _HEAD may have been prefetched from memory, but will not yet have started processing. After an error, JS  n _HEAD contains the address of the first job (chronologically) that failed. The status registers contain the state of this job. If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS1HEAD_HI             ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501888++0x03
    line.long 0x00 "JS1_TAIL_LO,   If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS1TAIL_LO             ,   This register contains the address of the oldest job that has finished issuing tasks, but is still running. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register. All the jobs in a job chain from JS  n _TAIL to JS n _HEAD are in some way active in the GPU. Jobs older than JS n _TAIL are fully completed. Note that the value in the JS  n _TAIL register is updated when a new job starts. Therefore, this value is only valid while the JS n _STATUS register has the value ACTIVE. After an error, JS  n _TAIL contains the address of the first job in the chain that is not known to be successfully complete. Other jobs after this point may have completed successfully, but all jobs prior to this point are guaranteed have completed.       In order to simplfy implementation of this feature, the position reported in JS n _TAIL is allowed to be conservative. However, scanning from this point forward in the chain will always be sufficient to identify all failing jobs."

group d:0xC050188C++0x03
    line.long 0x00 "JS1_TAIL_HI,   If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS1TAIL_HI             ,   This register contains the address of the oldest job that has finished issuing tasks, but is still running. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register. All the jobs in a job chain from JS  n _TAIL to JS n _HEAD are in some way active in the GPU. Jobs older than JS n _TAIL are fully completed. Note that the value in the JS  n _TAIL register is updated when a new job starts. Therefore, this value is only valid while the JS n _STATUS register has the value ACTIVE. After an error, JS  n _TAIL contains the address of the first job in the chain that is not known to be successfully complete. Other jobs after this point may have completed successfully, but all jobs prior to this point are guaranteed have completed.       In order to simplfy implementation of this feature, the position reported in JS n _TAIL is allowed to be conservative. However, scanning from this point forward in the chain will always be sufficient to identify all failing jobs."

group d:0xC0501890++0x03
    line.long 0x00 "JS1_AFFINITY_LO,   This register contains the current core affinity mask for this job slot. Only cores covered by the affinity mask are eligible for running tasks on. The mask is anded with the *_READY masks, and the resulting ones are the cores that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains.See also JS  n _XAFFINITY"
        hexmask.long 0x00 0.--31. 1. " JS1AFFINITY_LO         ,JS1AFFINITY_LO"

group d:0xC0501894++0x03
    line.long 0x00 "JS1_AFFINITY_HI,   This register contains the current core affinity mask for this job slot. Only cores covered by the affinity mask are eligible for running tasks on. The mask is anded with the *_READY masks, and the resulting ones are the cores that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains.See also JS  n _XAFFINITY"
        hexmask.long 0x00 0.--31. 1. " JS1AFFINITY_HI         ,JS1AFFINITY_HI"

group d:0xC0501898++0x03
    line.long 0x00 "JS1_CONFIG,   The job slot configuration register contains various configuration options for the jobs running in this job slot. "
        bitfld.long 0x00 4.--7. " Res84                  ,Res84" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.word 0x00 20.--31. 1. "        Res85                        ,Res85"
        bitfld.long 0x00 0.--3. "                                 ADDRESS_SPACE ,   This is the ID of the address space to use for execution of all the jobs in this job chain.       Address space configuration values are read from the AS  n registers.       Specifying an address space that is not supported (i.e. the corresponding bit in AS_PRESENT is 0) may result in UNDEFINED behavior." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 11. "                                   JOB_CHAIN_FLAG ,   The JOB_CHAIN_FLAG is set and read by software, and is used to disambiguate short-running job chains. It has no effect on the execution of a job, but is transferred intact from the JS  n _CONFIG_NEXT register to the JS n _CONFIG register when a job starts." "0,1"
        textline "                                "
        bitfld.long 0x00 16.--19. "THREAD_PRI             ,   The thread priority is ordered so that high values will cause threads to be issued faster. Priority values are relative to the other jobs running  if no other jobs are issuing threads, this job will never be throttled even with low priorities.  How the priority values affect issue rates from different slots is implementation dependent. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--9. "        START_FLUSH                  ,   Before the job chain is started, the selected action is applied to all caches except the tiler cache.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         Any non-zero value in this field will cause both a clean  and an invalidate for the read-write caches.         If the value is 3, then the read-only caches are also invalidated, as specified.         The flush command goes to all GPU cores enabled in the affinity mask, and the L2 cache." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 12.--13. "  END_FLUSH     ,   After the job chain is finished, the selected action is applied to all caches including the tiler cache. This happens when the job chain ends with a success code, or a fault code other than JOB_CONFIG_FAULT or JOB_POWER_FAULT. In the case of JOB_CONFIG_FAULT and JOB_POWER_FAULT, the job chain could not even start and so no cache flush on end takes place.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         The flush command goes only to the L2 cache. The tiler cache is not affected.         Any non-zero value in this field will cause both a clean  and an invalidate." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 10. "  START_MMU      ,START_MMU" "false:  No MMU actions ,true"
        textline "                                "
        bitfld.long 0x00 14. "ENABLE_FLUSH_REDUCTION ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a suppressable flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed. Otherwise, the flush  may be suppressed. Not all flushes can be suppressed, and not all suppressable flushes may be suppressed in any particular hardware implementation. In particular:    A CLEAN_INVALIDATE operation can replace a CLEAN, but not the other way around.  A CLEAN_INVALIDATE operation can be suppressed at the start of a job chain.  A CLEAN or CLEAN_INVALIDATE operation at the end of a job chain cannot be suppressed in the general case.  If software can guarantee that it will not read the result of a job chain until another job chain has been completed, then this is a case where the CLEAN or CLEAN_INVALIDATE operation at the end of a job chain could be suppressed. It is, however, simpler for software to signal this guarantee by simply not enabling the end-of-chain cache flush at all.  Explicit cache flush jobs are assumed to have been placed into the job chain for a reason, and are therefore not suppressed.  Clarified cache flush reduction  Added cache flush reduction " "false,true"
        bitfld.long 0x00 15. "     DISABLE_DESCRIPTOR_WRITEBACK ,   Normally, the status of each job in the job chain is written back as it is completed. This flag allows software to suppress that mechanism in cases where it is not required. Regardless of the setting of this flag, a job slot's  STATUS register is always updated on completion of its job chain. One of the reasons for writing back the status to the job descriptors is to guard against infinite loops in job chains. If this flag is set, then that protection is disabled and additional steps should be taken to detect and mitigate infinite loops.  Added  DISABLE_DESCRIPTOR_WRITEBACK flag to job slot CONFIG register." "false,true"

group d:0xC050189C++0x03
    line.long 0x00 "JS1_XAFFINITY,   Additional affinity information for job slot  n exists in this register. Only resources covered by the affinity mask are eligible for receiving commands. The mask is anded with the appropriate bits from the TILER_PRESENT and L2_PRESENT masks, and the resulting ones are the resources that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains. "
        hexmask.long.byte 0x00 1.--7. 1. " Res86                  ,Res86"
        bitfld.long 0x00 0. "        XAFFINITY_ENABLE             ,XAFFINITY_ENABLE" "false,true:  This register is enabled. "
        hexmask.long.byte 0x00 8.--15. 1. "    TILER_ENABLE  ,   This field selects which tilers receive commands such as cache flushes and tiler jobs. "
        hexmask.long.word 0x00 16.--31. 1. "                                   CACHE_ENABLE   ,   This field selects which level 2 caches receive commands such as cache flushes and tiler jobs. "

group d:0xC05018A0++0x03
    line.long 0x00 "JS1_COMMAND,   Writing values to this register will control the job currently running in job slot  n . When the Job Manager encounters the end of a job chain, an interrupt is generated and (if appropriate) the contents of the next registers are transferred to the current registers, allowing immediate execution of a new job chain.  Jobs can be started only by writing to the JS  n _COMMAND_NEXT register, not this register, as this process depends on reliable transfer of the other values describing the job. A soft stop requests that no more tasks are issued for a job, and once all running tasks are finished, the job state is written to memory and the job suspended. It is possible to recover from this state and continue the job.  A hard stop simply aborts all running tasks for a job. No attempt is made to finish, write partial results, or save state. It will not be possible to resume a job after a hard stop, although it may be possible to restart it from scratch if it does not write to its own inputs. To do this, the driver must set the job status to STOPPED and also set the restart index to 0.  The conditional versions of SOFT_STOP and HARD_STOP are designed to eliminate race conditions when checking the JOB_CHAIN_FLAG, which is in the JS  n _CONFIG register. The stop command is only issued if the current state of the flag matches the value in the command name. If it does not match, then the command is treated like a NOP and nothing happens."
        hexmask.long 0x00 0.--31. 1. " JS1COMMAND             ,   Added SUSPEND and RESUME commands to job chain  COMMAND register."

group d:0xC05018A4++0x03
    line.long 0x00 "JS1_STATUS,   This register indicates the status of the job chain running in this job slot.  During typical operation, the status starts in state  NOT_STARTED , then switches to ACTIVE during job chain execution, and on completion the status will change to either DONE for successful execution, or another exception code if an error occurred. Corrected description of job slot STATUS register  If the GPU is in protected mode, this register will read as zero. "
        hexmask.long.tbyte 0x00 8.--31. 1. " Res87                  ,Res87"
        hexmask.long.byte 0x00 0.--7. 1. "    EXCEPTION_TYPE               ,   Added new MMU exception types.  Changed INTERRUPTED exception type to SUSPENDED.  Added exception types for new events EUREKA and KABOOM.  Removed aliases for OK - used to also be called IDLE and NOT_STARTED.  Documented that a KABOOM instruction will cause other jobs to hard-stop.  Removed OUT_OF_MEMORY_AFBC error as it can only occur with non-sparse allocation (now removed).  Removed INSTR_TYPE_MISMATCH, INSTR_OPERAND_FAULT, INSTR_TLS_FAULT, INSTR_ALIGN_FAULT; added IMPRECISE_FAULT (0x5B).  Split SHAREABILITY_FAULT into GPU_SHAREABILITY_FAULT, SYSTEM_SHAREABILITY_FAULT and GPU_CACHEABILITY_FAULT. "

group d:0xC05018B0++0x03
    line.long 0x00 "JS1_FLUSH_ID,   This register contains the current cache flush ID for this job slot. "
        hexmask.long 0x00 0.--31. 1. " JS1FLUSH_ID            ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed.  Care must be taken in the overflow case. If the software setting up the ID detects that an overflow may occur, the job chain should be tagged with the maximum value of the  LATEST_FLUSH register. This ensures that flushes are correctly performed, at the possible cost of a few redundant flushes. Added cache flush reduction "

group d:0xC05018B4++0x03
    line.long 0x00 "JS1_EVENT_0,   This register is used to accumulate events for job chains where the job chain disambiguation bit is 0.  Added event registers to job slots. "
        hexmask.long 0x00 0.--31. 1. " JS1EVENT_0             ,JS1EVENT_0"

group d:0xC05018B8++0x03
    line.long 0x00 "JS1_EVENT_1,   This register is used to accumulate events for job chains where the job chain disambiguation bit is 1. "
        hexmask.long 0x00 0.--31. 1. " JS1EVENT_1             ,JS1EVENT_1"

group d:0xC05018BC++0x03
    line.long 0x00 "JS1_EVENT_MASK,   This register is the current event mask. "
        hexmask.long 0x00 0.--31. 1. " JS1EVENT_MASK          ,JS1EVENT_MASK"

group d:0xC05018C0++0x03
    line.long 0x00 "JS1_HEAD_NEXT_LO,   This register contains the value to be transferred into the JS  n _HEAD register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS1HEAD_NEXT_LO        ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC05018C4++0x03
    line.long 0x00 "JS1_HEAD_NEXT_HI,   This register contains the value to be transferred into the JS  n _HEAD register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS1HEAD_NEXT_HI        ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC05018D0++0x03
    line.long 0x00 "JS1_AFFINITY_NEXT_LO,   This register contains the value to be transferred into the JS  n _AFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS1AFFINITY_NEXT_LO    ,JS1AFFINITY_NEXT_LO"

group d:0xC05018D4++0x03
    line.long 0x00 "JS1_AFFINITY_NEXT_HI,   This register contains the value to be transferred into the JS  n _AFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS1AFFINITY_NEXT_HI    ,JS1AFFINITY_NEXT_HI"

group d:0xC05018D8++0x03
    line.long 0x00 "JS1_CONFIG_NEXT,   This register contains the value to be transferred into the JS  n _CONFIG register when the next job chain starts. See COMMAND_NEXT for details."
        bitfld.long 0x00 4.--7. " Res88                  ,Res88" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.word 0x00 20.--31. 1. "        Res89                        ,Res89"
        bitfld.long 0x00 0.--3. "                                 ADDRESS_SPACE ,   This is the ID of the address space to use for execution of all the jobs in this job chain.       Address space configuration values are read from the AS  n registers.       Specifying an address space that is not supported (i.e. the corresponding bit in AS_PRESENT is 0) may result in UNDEFINED behavior." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 11. "                                   JOB_CHAIN_FLAG ,   The JOB_CHAIN_FLAG is set and read by software, and is used to disambiguate short-running job chains. It has no effect on the execution of a job, but is transferred intact from the JS  n _CONFIG_NEXT register to the JS n _CONFIG register when a job starts." "0,1"
        textline "                                "
        bitfld.long 0x00 16.--19. "THREAD_PRI             ,   The thread priority is ordered so that high values will cause threads to be issued faster. Priority values are relative to the other jobs running  if no other jobs are issuing threads, this job will never be throttled even with low priorities.  How the priority values affect issue rates from different slots is implementation dependent. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--9. "        START_FLUSH                  ,   Before the job chain is started, the selected action is applied to all caches except the tiler cache.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         Any non-zero value in this field will cause both a clean  and an invalidate for the read-write caches.         If the value is 3, then the read-only caches are also invalidated, as specified.         The flush command goes to all GPU cores enabled in the affinity mask, and the L2 cache." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 12.--13. "  END_FLUSH     ,   After the job chain is finished, the selected action is applied to all caches including the tiler cache. This happens when the job chain ends with a success code, or a fault code other than JOB_CONFIG_FAULT or JOB_POWER_FAULT. In the case of JOB_CONFIG_FAULT and JOB_POWER_FAULT, the job chain could not even start and so no cache flush on end takes place.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         The flush command goes only to the L2 cache. The tiler cache is not affected.         Any non-zero value in this field will cause both a clean  and an invalidate." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 10. "  START_MMU      ,START_MMU" "false:  No MMU actions ,true"
        textline "                                "
        bitfld.long 0x00 14. "ENABLE_FLUSH_REDUCTION ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a suppressable flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed. Otherwise, the flush  may be suppressed. Not all flushes can be suppressed, and not all suppressable flushes may be suppressed in any particular hardware implementation. In particular:    A CLEAN_INVALIDATE operation can replace a CLEAN, but not the other way around.  A CLEAN_INVALIDATE operation can be suppressed at the start of a job chain.  A CLEAN or CLEAN_INVALIDATE operation at the end of a job chain cannot be suppressed in the general case.  If software can guarantee that it will not read the result of a job chain until another job chain has been completed, then this is a case where the CLEAN or CLEAN_INVALIDATE operation at the end of a job chain could be suppressed. It is, however, simpler for software to signal this guarantee by simply not enabling the end-of-chain cache flush at all.  Explicit cache flush jobs are assumed to have been placed into the job chain for a reason, and are therefore not suppressed.  Clarified cache flush reduction  Added cache flush reduction " "false,true"
        bitfld.long 0x00 15. "     DISABLE_DESCRIPTOR_WRITEBACK ,   Normally, the status of each job in the job chain is written back as it is completed. This flag allows software to suppress that mechanism in cases where it is not required. Regardless of the setting of this flag, a job slot's  STATUS register is always updated on completion of its job chain. One of the reasons for writing back the status to the job descriptors is to guard against infinite loops in job chains. If this flag is set, then that protection is disabled and additional steps should be taken to detect and mitigate infinite loops.  Added  DISABLE_DESCRIPTOR_WRITEBACK flag to job slot CONFIG register." "false,true"

group d:0xC05018DC++0x03
    line.long 0x00 "JS1_XAFFINITY_NEXT,   This register contains the value to be transferred into the JS  n _XAFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long.byte 0x00 1.--7. 1. " Res90                  ,Res90"
        bitfld.long 0x00 0. "        XAFFINITY_ENABLE             ,XAFFINITY_ENABLE" "false,true:  This register is enabled. "
        hexmask.long.byte 0x00 8.--15. 1. "    TILER_ENABLE  ,   This field selects which tilers receive commands such as cache flushes and tiler jobs. "
        hexmask.long.word 0x00 16.--31. 1. "                                   CACHE_ENABLE   ,   This field selects which level 2 caches receive commands such as cache flushes and tiler jobs. "

group d:0xC05018E0++0x03
    line.long 0x00 "JS1_COMMAND_NEXT,   When the current job chain is completed, if there are no unacknowledged errors from the previous job chain, and this register is not set to NOP,      then the contents of the *_NEXT registers are transferred to the corresponding current * registers. This allows software to construct job chains one ahead and maintain throughput.  When the values are transferred, the JS  n _COMMAND_NEXT register is cleared, indicating a NOP. The register is then ready to accept a new command. The JS n _HEAD_NEXT register is also cleared at the same time. The state of the current job can be determined using JS n _STATUS. In order to prevent new chains being transferred in a half-completed state, data is transferred only when a START command is present in the JS  n _COMMAND_NEXT register. Therefore, software should initialize the other _NEXT registers first, and only write a START command to the JS n _COMMAND_NEXT register when the data for the next job is complete. If there is no job running in slot n when START is written to JS  n _COMMAND_NEXT, the next data is transferred immediately.      If the next command value is anything except START, nothing happens. To stop jobs, write STOP commands to the JS  n _COMMAND register instead. If any status is returned from a job in the previous job chain other than DONE, the JOB_FAIL_  n bit for this job chain is set in the JOB_IRQ_RAWSTAT register, and the next job chain is not started. This allows software to retrieve the current register values. Software must indicate that it is ready to proceed by clearing the error interrupt bit, at which point the next job chain may be started."
        hexmask.long 0x00 0.--31. 1. " JS1COMMAND_NEXT        ,   Added SUSPEND and RESUME commands to job chain  COMMAND register."

group d:0xC05018F0++0x03
    line.long 0x00 "JS1_FLUSH_ID_NEXT,   This register contains the value to be transferred into the JS  n _FLUSH_ID register when the next job chain starts. See FLUSH_ID for details."
        hexmask.long 0x00 0.--31. 1. " JS1FLUSH_ID_NEXT       ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed.  Care must be taken in the overflow case. If the software setting up the ID detects that an overflow may occur, the job chain should be tagged with the maximum value of the  LATEST_FLUSH register. This ensures that flushes are correctly performed, at the possible cost of a few redundant flushes. Added cache flush reduction "

group d:0xC05018FC++0x03
    line.long 0x00 "JS1_EVENT_MASK_NEXT,   This register contains the value to be transferred into the JS  n _EVENT_MASK register when the next job chain starts. See EVENT_MASK for details."
        hexmask.long 0x00 0.--31. 1. " JS1EVENT_MASK_NEXT     ,JS1EVENT_MASK_NEXT"

width 22.

group d:0xC0501900++0x03
    line.long 0x00 "JS2_HEAD_LO,   These registers exist for each supported job slot, with the prefix JS  n . To start a job chain, write the address to the first job descriptor into the JS  n _HEAD_NEXT register and write a START command to the JS n _COMMAND_NEXT register. When read, this register reflects the current position in the job chain. When the Job Manager has finished issuing tasks for a job, it will go on to the next job in the job chain, and update JS  n _HEAD. A job will disappear from JS  n _HEAD before it has finished processing all its tasks. See JS n _TAIL for how to discover this. Jobs newer than JS  n _HEAD may have been prefetched from memory, but will not yet have started processing. After an error, JS  n _HEAD contains the address of the first job (chronologically) that failed. The status registers contain the state of this job. If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS2HEAD_LO             ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501904++0x03
    line.long 0x00 "JS2_HEAD_HI,   These registers exist for each supported job slot, with the prefix JS  n . To start a job chain, write the address to the first job descriptor into the JS  n _HEAD_NEXT register and write a START command to the JS n _COMMAND_NEXT register. When read, this register reflects the current position in the job chain. When the Job Manager has finished issuing tasks for a job, it will go on to the next job in the job chain, and update JS  n _HEAD. A job will disappear from JS  n _HEAD before it has finished processing all its tasks. See JS n _TAIL for how to discover this. Jobs newer than JS  n _HEAD may have been prefetched from memory, but will not yet have started processing. After an error, JS  n _HEAD contains the address of the first job (chronologically) that failed. The status registers contain the state of this job. If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS2HEAD_HI             ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501908++0x03
    line.long 0x00 "JS2_TAIL_LO,   If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS2TAIL_LO             ,   This register contains the address of the oldest job that has finished issuing tasks, but is still running. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register. All the jobs in a job chain from JS  n _TAIL to JS n _HEAD are in some way active in the GPU. Jobs older than JS n _TAIL are fully completed. Note that the value in the JS  n _TAIL register is updated when a new job starts. Therefore, this value is only valid while the JS n _STATUS register has the value ACTIVE. After an error, JS  n _TAIL contains the address of the first job in the chain that is not known to be successfully complete. Other jobs after this point may have completed successfully, but all jobs prior to this point are guaranteed have completed.       In order to simplfy implementation of this feature, the position reported in JS n _TAIL is allowed to be conservative. However, scanning from this point forward in the chain will always be sufficient to identify all failing jobs."

group d:0xC050190C++0x03
    line.long 0x00 "JS2_TAIL_HI,   If the GPU is in protected mode, this register will read as zero. "
        hexmask.long 0x00 0.--31. 1. " JS2TAIL_HI             ,   This register contains the address of the oldest job that has finished issuing tasks, but is still running. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register. All the jobs in a job chain from JS  n _TAIL to JS n _HEAD are in some way active in the GPU. Jobs older than JS n _TAIL are fully completed. Note that the value in the JS  n _TAIL register is updated when a new job starts. Therefore, this value is only valid while the JS n _STATUS register has the value ACTIVE. After an error, JS  n _TAIL contains the address of the first job in the chain that is not known to be successfully complete. Other jobs after this point may have completed successfully, but all jobs prior to this point are guaranteed have completed.       In order to simplfy implementation of this feature, the position reported in JS n _TAIL is allowed to be conservative. However, scanning from this point forward in the chain will always be sufficient to identify all failing jobs."

group d:0xC0501910++0x03
    line.long 0x00 "JS2_AFFINITY_LO,   This register contains the current core affinity mask for this job slot. Only cores covered by the affinity mask are eligible for running tasks on. The mask is anded with the *_READY masks, and the resulting ones are the cores that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains.See also JS  n _XAFFINITY"
        hexmask.long 0x00 0.--31. 1. " JS2AFFINITY_LO         ,JS2AFFINITY_LO"

group d:0xC0501914++0x03
    line.long 0x00 "JS2_AFFINITY_HI,   This register contains the current core affinity mask for this job slot. Only cores covered by the affinity mask are eligible for running tasks on. The mask is anded with the *_READY masks, and the resulting ones are the cores that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains.See also JS  n _XAFFINITY"
        hexmask.long 0x00 0.--31. 1. " JS2AFFINITY_HI         ,JS2AFFINITY_HI"

group d:0xC0501918++0x03
    line.long 0x00 "JS2_CONFIG,   The job slot configuration register contains various configuration options for the jobs running in this job slot. "
        bitfld.long 0x00 4.--7. " Res91                  ,Res91" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.word 0x00 20.--31. 1. "        Res92                        ,Res92"
        bitfld.long 0x00 0.--3. "                                 ADDRESS_SPACE ,   This is the ID of the address space to use for execution of all the jobs in this job chain.       Address space configuration values are read from the AS  n registers.       Specifying an address space that is not supported (i.e. the corresponding bit in AS_PRESENT is 0) may result in UNDEFINED behavior." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 11. "                                   JOB_CHAIN_FLAG ,   The JOB_CHAIN_FLAG is set and read by software, and is used to disambiguate short-running job chains. It has no effect on the execution of a job, but is transferred intact from the JS  n _CONFIG_NEXT register to the JS n _CONFIG register when a job starts." "0,1"
        textline "                                "
        bitfld.long 0x00 16.--19. "THREAD_PRI             ,   The thread priority is ordered so that high values will cause threads to be issued faster. Priority values are relative to the other jobs running  if no other jobs are issuing threads, this job will never be throttled even with low priorities.  How the priority values affect issue rates from different slots is implementation dependent. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--9. "        START_FLUSH                  ,   Before the job chain is started, the selected action is applied to all caches except the tiler cache.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         Any non-zero value in this field will cause both a clean  and an invalidate for the read-write caches.         If the value is 3, then the read-only caches are also invalidated, as specified.         The flush command goes to all GPU cores enabled in the affinity mask, and the L2 cache." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 12.--13. "  END_FLUSH     ,   After the job chain is finished, the selected action is applied to all caches including the tiler cache. This happens when the job chain ends with a success code, or a fault code other than JOB_CONFIG_FAULT or JOB_POWER_FAULT. In the case of JOB_CONFIG_FAULT and JOB_POWER_FAULT, the job chain could not even start and so no cache flush on end takes place.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         The flush command goes only to the L2 cache. The tiler cache is not affected.         Any non-zero value in this field will cause both a clean  and an invalidate." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 10. "  START_MMU      ,START_MMU" "false:  No MMU actions ,true"
        textline "                                "
        bitfld.long 0x00 14. "ENABLE_FLUSH_REDUCTION ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a suppressable flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed. Otherwise, the flush  may be suppressed. Not all flushes can be suppressed, and not all suppressable flushes may be suppressed in any particular hardware implementation. In particular:    A CLEAN_INVALIDATE operation can replace a CLEAN, but not the other way around.  A CLEAN_INVALIDATE operation can be suppressed at the start of a job chain.  A CLEAN or CLEAN_INVALIDATE operation at the end of a job chain cannot be suppressed in the general case.  If software can guarantee that it will not read the result of a job chain until another job chain has been completed, then this is a case where the CLEAN or CLEAN_INVALIDATE operation at the end of a job chain could be suppressed. It is, however, simpler for software to signal this guarantee by simply not enabling the end-of-chain cache flush at all.  Explicit cache flush jobs are assumed to have been placed into the job chain for a reason, and are therefore not suppressed.  Clarified cache flush reduction  Added cache flush reduction " "false,true"
        bitfld.long 0x00 15. "     DISABLE_DESCRIPTOR_WRITEBACK ,   Normally, the status of each job in the job chain is written back as it is completed. This flag allows software to suppress that mechanism in cases where it is not required. Regardless of the setting of this flag, a job slot's  STATUS register is always updated on completion of its job chain. One of the reasons for writing back the status to the job descriptors is to guard against infinite loops in job chains. If this flag is set, then that protection is disabled and additional steps should be taken to detect and mitigate infinite loops.  Added  DISABLE_DESCRIPTOR_WRITEBACK flag to job slot CONFIG register." "false,true"

group d:0xC050191C++0x03
    line.long 0x00 "JS2_XAFFINITY,   Additional affinity information for job slot  n exists in this register. Only resources covered by the affinity mask are eligible for receiving commands. The mask is anded with the appropriate bits from the TILER_PRESENT and L2_PRESENT masks, and the resulting ones are the resources that can be used.  The affinity value is constant over a job chain. If you need to change affinity between jobs, then they must be split into separate job chains. "
        hexmask.long.byte 0x00 1.--7. 1. " Res93                  ,Res93"
        bitfld.long 0x00 0. "        XAFFINITY_ENABLE             ,XAFFINITY_ENABLE" "false,true:  This register is enabled. "
        hexmask.long.byte 0x00 8.--15. 1. "    TILER_ENABLE  ,   This field selects which tilers receive commands such as cache flushes and tiler jobs. "
        hexmask.long.word 0x00 16.--31. 1. "                                   CACHE_ENABLE   ,   This field selects which level 2 caches receive commands such as cache flushes and tiler jobs. "

group d:0xC0501920++0x03
    line.long 0x00 "JS2_COMMAND,   Writing values to this register will control the job currently running in job slot  n . When the Job Manager encounters the end of a job chain, an interrupt is generated and (if appropriate) the contents of the next registers are transferred to the current registers, allowing immediate execution of a new job chain.  Jobs can be started only by writing to the JS  n _COMMAND_NEXT register, not this register, as this process depends on reliable transfer of the other values describing the job. A soft stop requests that no more tasks are issued for a job, and once all running tasks are finished, the job state is written to memory and the job suspended. It is possible to recover from this state and continue the job.  A hard stop simply aborts all running tasks for a job. No attempt is made to finish, write partial results, or save state. It will not be possible to resume a job after a hard stop, although it may be possible to restart it from scratch if it does not write to its own inputs. To do this, the driver must set the job status to STOPPED and also set the restart index to 0.  The conditional versions of SOFT_STOP and HARD_STOP are designed to eliminate race conditions when checking the JOB_CHAIN_FLAG, which is in the JS  n _CONFIG register. The stop command is only issued if the current state of the flag matches the value in the command name. If it does not match, then the command is treated like a NOP and nothing happens."
        hexmask.long 0x00 0.--31. 1. " JS2COMMAND             ,   Added SUSPEND and RESUME commands to job chain  COMMAND register."

group d:0xC0501924++0x03
    line.long 0x00 "JS2_STATUS,   This register indicates the status of the job chain running in this job slot.  During typical operation, the status starts in state  NOT_STARTED , then switches to ACTIVE during job chain execution, and on completion the status will change to either DONE for successful execution, or another exception code if an error occurred. Corrected description of job slot STATUS register  If the GPU is in protected mode, this register will read as zero. "
        hexmask.long.tbyte 0x00 8.--31. 1. " Res94                  ,Res94"
        hexmask.long.byte 0x00 0.--7. 1. "    EXCEPTION_TYPE               ,   Added new MMU exception types.  Changed INTERRUPTED exception type to SUSPENDED.  Added exception types for new events EUREKA and KABOOM.  Removed aliases for OK - used to also be called IDLE and NOT_STARTED.  Documented that a KABOOM instruction will cause other jobs to hard-stop.  Removed OUT_OF_MEMORY_AFBC error as it can only occur with non-sparse allocation (now removed).  Removed INSTR_TYPE_MISMATCH, INSTR_OPERAND_FAULT, INSTR_TLS_FAULT, INSTR_ALIGN_FAULT; added IMPRECISE_FAULT (0x5B).  Split SHAREABILITY_FAULT into GPU_SHAREABILITY_FAULT, SYSTEM_SHAREABILITY_FAULT and GPU_CACHEABILITY_FAULT. "

group d:0xC0501930++0x03
    line.long 0x00 "JS2_FLUSH_ID,   This register contains the current cache flush ID for this job slot. "
        hexmask.long 0x00 0.--31. 1. " JS2FLUSH_ID            ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed.  Care must be taken in the overflow case. If the software setting up the ID detects that an overflow may occur, the job chain should be tagged with the maximum value of the  LATEST_FLUSH register. This ensures that flushes are correctly performed, at the possible cost of a few redundant flushes. Added cache flush reduction "

group d:0xC0501934++0x03
    line.long 0x00 "JS2_EVENT_0,   This register is used to accumulate events for job chains where the job chain disambiguation bit is 0.  Added event registers to job slots. "
        hexmask.long 0x00 0.--31. 1. " JS2EVENT_0             ,JS2EVENT_0"

group d:0xC0501938++0x03
    line.long 0x00 "JS2_EVENT_1,   This register is used to accumulate events for job chains where the job chain disambiguation bit is 1. "
        hexmask.long 0x00 0.--31. 1. " JS2EVENT_1             ,JS2EVENT_1"

group d:0xC050193C++0x03
    line.long 0x00 "JS2_EVENT_MASK,   This register is the current event mask. "
        hexmask.long 0x00 0.--31. 1. " JS2EVENT_MASK          ,JS2EVENT_MASK"

group d:0xC0501940++0x03
    line.long 0x00 "JS2_HEAD_NEXT_LO,   This register contains the value to be transferred into the JS  n _HEAD register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS2HEAD_NEXT_LO        ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501944++0x03
    line.long 0x00 "JS2_HEAD_NEXT_HI,   This register contains the value to be transferred into the JS  n _HEAD register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS2HEAD_NEXT_HI        ,   This register contains the address of the current job descriptor. The address is a virtual address in the address space specified by the ADDRESS_SPACE field in the JS  n _CONFIG register."

group d:0xC0501950++0x03
    line.long 0x00 "JS2_AFFINITY_NEXT_LO,   This register contains the value to be transferred into the JS  n _AFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS2AFFINITY_NEXT_LO    ,JS2AFFINITY_NEXT_LO"

group d:0xC0501954++0x03
    line.long 0x00 "JS2_AFFINITY_NEXT_HI,   This register contains the value to be transferred into the JS  n _AFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long 0x00 0.--31. 1. " JS2AFFINITY_NEXT_HI    ,JS2AFFINITY_NEXT_HI"

group d:0xC0501958++0x03
    line.long 0x00 "JS2_CONFIG_NEXT,   This register contains the value to be transferred into the JS  n _CONFIG register when the next job chain starts. See COMMAND_NEXT for details."
        bitfld.long 0x00 4.--7. " Res95                  ,Res95" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.word 0x00 20.--31. 1. "        Res96                        ,Res96"
        bitfld.long 0x00 0.--3. "                                 ADDRESS_SPACE ,   This is the ID of the address space to use for execution of all the jobs in this job chain.       Address space configuration values are read from the AS  n registers.       Specifying an address space that is not supported (i.e. the corresponding bit in AS_PRESENT is 0) may result in UNDEFINED behavior." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 11. "                                   JOB_CHAIN_FLAG ,   The JOB_CHAIN_FLAG is set and read by software, and is used to disambiguate short-running job chains. It has no effect on the execution of a job, but is transferred intact from the JS  n _CONFIG_NEXT register to the JS n _CONFIG register when a job starts." "0,1"
        textline "                                "
        bitfld.long 0x00 16.--19. "THREAD_PRI             ,   The thread priority is ordered so that high values will cause threads to be issued faster. Priority values are relative to the other jobs running  if no other jobs are issuing threads, this job will never be throttled even with low priorities.  How the priority values affect issue rates from different slots is implementation dependent. " "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--9. "        START_FLUSH                  ,   Before the job chain is started, the selected action is applied to all caches except the tiler cache.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         Any non-zero value in this field will cause both a clean  and an invalidate for the read-write caches.         If the value is 3, then the read-only caches are also invalidated, as specified.         The flush command goes to all GPU cores enabled in the affinity mask, and the L2 cache." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 12.--13. "  END_FLUSH     ,   After the job chain is finished, the selected action is applied to all caches including the tiler cache. This happens when the job chain ends with a success code, or a fault code other than JOB_CONFIG_FAULT or JOB_POWER_FAULT. In the case of JOB_CONFIG_FAULT and JOB_POWER_FAULT, the job chain could not even start and so no cache flush on end takes place.  Clarified that cache flush behavior for Mimir deviates from spec.  In this implementation (MIMIR), this behavior is not fully implemented.         The flush command goes only to the L2 cache. The tiler cache is not affected.         Any non-zero value in this field will cause both a clean  and an invalidate." "NO_ACTION:  No action is performed ,CLEAN,2,INVALIDATE"
        bitfld.long 0x00 10. "  START_MMU      ,START_MMU" "false:  No MMU actions ,true"
        textline "                                "
        bitfld.long 0x00 14. "ENABLE_FLUSH_REDUCTION ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a suppressable flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed. Otherwise, the flush  may be suppressed. Not all flushes can be suppressed, and not all suppressable flushes may be suppressed in any particular hardware implementation. In particular:    A CLEAN_INVALIDATE operation can replace a CLEAN, but not the other way around.  A CLEAN_INVALIDATE operation can be suppressed at the start of a job chain.  A CLEAN or CLEAN_INVALIDATE operation at the end of a job chain cannot be suppressed in the general case.  If software can guarantee that it will not read the result of a job chain until another job chain has been completed, then this is a case where the CLEAN or CLEAN_INVALIDATE operation at the end of a job chain could be suppressed. It is, however, simpler for software to signal this guarantee by simply not enabling the end-of-chain cache flush at all.  Explicit cache flush jobs are assumed to have been placed into the job chain for a reason, and are therefore not suppressed.  Clarified cache flush reduction  Added cache flush reduction " "false,true"
        bitfld.long 0x00 15. "     DISABLE_DESCRIPTOR_WRITEBACK ,   Normally, the status of each job in the job chain is written back as it is completed. This flag allows software to suppress that mechanism in cases where it is not required. Regardless of the setting of this flag, a job slot's  STATUS register is always updated on completion of its job chain. One of the reasons for writing back the status to the job descriptors is to guard against infinite loops in job chains. If this flag is set, then that protection is disabled and additional steps should be taken to detect and mitigate infinite loops.  Added  DISABLE_DESCRIPTOR_WRITEBACK flag to job slot CONFIG register." "false,true"

group d:0xC050195C++0x03
    line.long 0x00 "JS2_XAFFINITY_NEXT,   This register contains the value to be transferred into the JS  n _XAFFINITY register when the next job chain starts. See COMMAND_NEXT for details."
        hexmask.long.byte 0x00 1.--7. 1. " Res97                  ,Res97"
        bitfld.long 0x00 0. "        XAFFINITY_ENABLE             ,XAFFINITY_ENABLE" "false,true:  This register is enabled. "
        hexmask.long.byte 0x00 8.--15. 1. "    TILER_ENABLE  ,   This field selects which tilers receive commands such as cache flushes and tiler jobs. "
        hexmask.long.word 0x00 16.--31. 1. "                                   CACHE_ENABLE   ,   This field selects which level 2 caches receive commands such as cache flushes and tiler jobs. "

group d:0xC0501960++0x03
    line.long 0x00 "JS2_COMMAND_NEXT,   When the current job chain is completed, if there are no unacknowledged errors from the previous job chain, and this register is not set to NOP,      then the contents of the *_NEXT registers are transferred to the corresponding current * registers. This allows software to construct job chains one ahead and maintain throughput.  When the values are transferred, the JS  n _COMMAND_NEXT register is cleared, indicating a NOP. The register is then ready to accept a new command. The JS n _HEAD_NEXT register is also cleared at the same time. The state of the current job can be determined using JS n _STATUS. In order to prevent new chains being transferred in a half-completed state, data is transferred only when a START command is present in the JS  n _COMMAND_NEXT register. Therefore, software should initialize the other _NEXT registers first, and only write a START command to the JS n _COMMAND_NEXT register when the data for the next job is complete. If there is no job running in slot n when START is written to JS  n _COMMAND_NEXT, the next data is transferred immediately.      If the next command value is anything except START, nothing happens. To stop jobs, write STOP commands to the JS  n _COMMAND register instead. If any status is returned from a job in the previous job chain other than DONE, the JOB_FAIL_  n bit for this job chain is set in the JOB_IRQ_RAWSTAT register, and the next job chain is not started. This allows software to retrieve the current register values. Software must indicate that it is ready to proceed by clearing the error interrupt bit, at which point the next job chain may be started."
        hexmask.long 0x00 0.--31. 1. " JS2COMMAND_NEXT        ,   Added SUSPEND and RESUME commands to job chain  COMMAND register."

group d:0xC0501970++0x03
    line.long 0x00 "JS2_FLUSH_ID_NEXT,   This register contains the value to be transferred into the JS  n _FLUSH_ID register when the next job chain starts. See FLUSH_ID for details."
        hexmask.long 0x00 0.--31. 1. " JS2FLUSH_ID_NEXT       ,   When operating in 'cache flush reduction' mode, each job chain has an associated ID which is used to identify cache flushes.  This ID is a sequential 32-bit value. When the job manager is asked to perform a flush, it compares the job chain flush ID with the latest flush ID. If the job chain ID is greater than the latest flush, then a flush is performed.  Care must be taken in the overflow case. If the software setting up the ID detects that an overflow may occur, the job chain should be tagged with the maximum value of the  LATEST_FLUSH register. This ensures that flushes are correctly performed, at the possible cost of a few redundant flushes. Added cache flush reduction "

group d:0xC050197C++0x03
    line.long 0x00 "JS2_EVENT_MASK_NEXT,   This register contains the value to be transferred into the JS  n _EVENT_MASK register when the next job chain starts. See EVENT_MASK for details."
        hexmask.long 0x00 0.--31. 1. " JS2EVENT_MASK_NEXT     ,JS2EVENT_MASK_NEXT"

width 20.

group d:0xC0502000++0x03
    line.long 0x00 "ST1MMU_IRQ_RAWSTAT,   This register contains the raw unmasked interrupt sources for MMU status and exception handling.  Writing to this register may force bits on, but will not clear them.      The new state for a bit corresponding to an existing address space is the logical OR of the previous state and the written value, except     that bits corresponding to address spaces which do not exist will ignore writes and consistently read 0.  Writing a zero to a bit will have no effect. Use the IRQ_CLEAR register to clear interrupts.  Clarified that bits in MMU IRQ_RAWSTAT are dependent on existence of address spaces. "
        hexmask.long.word 0x00 0.--15. 1. " PAGE_FAULT ,PAGE_FAULT"
        hexmask.long.word 0x00 16.--31. 1. "  BUS_ERROR ,BUS_ERROR"

group d:0xC0502004++0x03
    line.long 0x00 "ST1MMU_IRQ_CLEAR,   This register has the same layout as  IRQ_RAWSTAT . Write a one to a bit in this register to clear the corresponding bit in IRQ_RAWSTAT. As for  IRQ_RAWSTAT , bits corresponding to address spaces which do not exist will ignore writes and consistently read 0."
        hexmask.long.word 0x00 0.--15. 1. " PAGE_FAULT ,PAGE_FAULT"
        hexmask.long.word 0x00 16.--31. 1. "  BUS_ERROR ,BUS_ERROR"

group d:0xC0502008++0x03
    line.long 0x00 "ST1MMU_IRQ_MASK,   This register has the same layout as  IRQ_RAWSTAT . Set each bit in this to one to enable the corresponding interrupt source, and to zero to disable it. As for  IRQ_RAWSTAT , bits corresponding to address spaces which do not exist will ignore writes and consistently read 0."
        hexmask.long.word 0x00 0.--15. 1. " PAGE_FAULT ,PAGE_FAULT"
        hexmask.long.word 0x00 16.--31. 1. "  BUS_ERROR ,BUS_ERROR"

group d:0xC050200C++0x03
    line.long 0x00 "ST1MMU_IRQ_STATUS,   This register has the same layout as  IRQ_RAWSTAT . This register contains the result of anding together IRQ_RAWSTAT and IRQ_MASK. If any bits in this register are set, the external GPU control interrupt line is asserted, signaling an interrupt request to the CPU."
        hexmask.long.word 0x00 0.--15. 1. " PAGE_FAULT ,PAGE_FAULT"
        hexmask.long.word 0x00 16.--31. 1. "  BUS_ERROR ,BUS_ERROR"

width 27.

group d:0xC0502400++0x03
    line.long 0x00 "ST1MMUAS0_TRANSTAB_LO,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        bitfld.long 0x00 0.--3. " Res98                    ,Res98" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long 0x00 4.--31. 1. "           ST1MMUAS0TRANSTAB_LO   ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502404++0x03
    line.long 0x00 "ST1MMUAS0_TRANSTAB_HI,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS0TRANSTAB_HI     ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502408++0x03
    line.long 0x00 "ST1MMUAS0_MEMATTR_LO,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE0               ,   This field specifies the memory attributes for memory type index 0. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE1             ,   This field specifies the memory attributes for memory type index 1. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE2           ,   This field specifies the memory attributes for memory type index 2. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE3       ,   This field specifies the memory attributes for memory type index 3. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE4               ,   This field specifies the memory attributes for memory type index 4. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE5             ,   This field specifies the memory attributes for memory type index 5. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE6           ,   This field specifies the memory attributes for memory type index 6. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE7       ,   This field specifies the memory attributes for memory type index 7. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC050240C++0x03
    line.long 0x00 "ST1MMUAS0_MEMATTR_HI,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE8               ,   This field specifies the memory attributes for memory type index 8. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE9             ,   This field specifies the memory attributes for memory type index 9. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE10          ,   This field specifies the memory attributes for memory type index 10. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE11      ,   This field specifies the memory attributes for memory type index 11. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE12              ,   This field specifies the memory attributes for memory type index 12. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE13            ,   This field specifies the memory attributes for memory type index 13. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE14          ,   This field specifies the memory attributes for memory type index 14. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE15      ,   This field specifies the memory attributes for memory type index 15. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC0502410++0x03
    line.long 0x00 "ST1MMUAS0_LOCKADDR_LO,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long.byte 0x00 6.--11. 1. " Res99                    ,Res99"
        hexmask.long.byte 0x00 0.--5. 1. "           LOCKADDR_SIZE          ,   This field contains the log  2 of the size of the region to lock, minus 1. Only values in the range 11 to 63 are valid values for this field, corresponding to region sizes of 4KB up to the entire address space. Values in the range 0 to 10 result in UNDEFINED behavior and should not be used."
        hexmask.long.tbyte 0x00 12.--31. 1. "             ST1MMUAS0LOCKADDR_LO ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502414++0x03
    line.long 0x00 "ST1MMUAS0_LOCKADDR_HI,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS0LOCKADDR_HI     ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502418++0x03
    line.long 0x00 "ST1MMUAS0_COMMAND,   MMU commands are issued by writing to this register. Any command written to an address space while the corresponding STATUS.AS_ACTIVE flag is set will be ignored.  In general an MMU command only applies to the address space it is submitted to. However a command that invalidates the MMU cache may invalidate the whole MMU cache rather than only those entries specific to one address space. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS0COMMAND         ,ST1MMUAS0COMMAND"

group d:0xC050241C++0x03
    line.long 0x00 "ST1MMUAS0_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.       If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  If the GPU is in protected mode, this register is not updated, and MMU faults are ignored.        They are not fatal but will halt the GPU until the MMU address space is updated.        However, no fault information wil be visible in this case.  Changed access type of MMU_FAULTSTATUS register when in protected mode. "
        hexmask.long.byte 0x00 10.--15. 1. " Res100                   ,Res100"
        hexmask.long.word 0x00 16.--31. 1. "           SOURCE_ID              ,   This field contains an implementation-defined ID that supplies additional data about the source of the fault. For example, it may be the ID of the internal bus master that issued the request that faulted. This makes it possible to distinguish between the job manager, the texture unit and the load/store unit. Another example might be an indication of the type of an invalid data structure. The values in this field are implementation defined. "
        hexmask.long.byte 0x00 0.--7. 1. "           EXCEPTION_TYPE       ,   This field indicates the type of exception that caused the fault. "
        bitfld.long 0x00 8.--9. "               ACCESS_TYPE      ,   This field contains the direction of data transfer that caused the fault, if known.  For the purposes of error reporting, atomic transactions act like a read followed by a write, so denying either permission will result in the atomic transaction failing, and the exceptions ACCESS_TYPE field will be set to 'atomic'. " "atomic,execute:  An execute transaction. ,read:  A read transaction. ,write:  A write transaction. "

group d:0xC0502420++0x03
    line.long 0x00 "ST1MMUAS0_FAULTADDRESS_LO,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS0FAULTADDRESS_LO ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC0502424++0x03
    line.long 0x00 "ST1MMUAS0_FAULTADDRESS_HI,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS0FAULTADDRESS_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC0502428++0x03
    line.long 0x00 "ST1MMUAS0_STATUS,   This register contains dynamic status information about this address space. "
        hexmask.long 0x00 1.--31. 1. " Res101                   ,Res101"
        bitfld.long 0x00 0. "     AS_ACTIVE              ,   This flag is set while a MMU_UPDATE, LOCK, UNLOCK, FLUSH_PT or FLUSH_MEM command is active on this address space. This allows software to safely verify that the address space is in a consistent state after reconfiguring the MMU page tables.  If a new command is written to the corresponding COMMAND register while the AS_ACTIVE bit is set, then the command is ignored. " "false,true"

group d:0xC0502430++0x03
    line.long 0x00 "ST1MMUAS0_TRANSCFG_LO,ST1MMUAS0_TRANSCFG_LO"
        bitfld.long 0x00 4.--5. " Res102                   ,Res102" "0,1,2,3"
        bitfld.long 0x00 11.--13. "            Res103                 ,Res103" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 19.--21. "              Res104               ,Res104" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 23. "                Res105           ,Res105" "0,1"
        textline "                                     "
        bitfld.long 0x00 26.--27. "Res106                   ,Res106" "0,1,2,3"
        bitfld.long 0x00 31. "            Res107                 ,Res107" "0,1"
        bitfld.long 0x00 6.--10. "              INA_BITS             ,   This field allows the system software to restrict the range of input addresses accepted by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  INA_BITS_VALID = min(HW_INA_BITS, 55-INA_BITS)  If the input address is outside the range (0, 2  INA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 14.--18. "               OUTA_BITS        ,   This field allows the system software to restrict the range of output addresses generated by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  OUTA_BITS_VALID = min(HW_OUTA_BITS, 55-OUTA_BITS)  If the translated output address is outside the range (0, 2  OUTA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                     "
        bitfld.long 0x00 0.--3. "MODE                     ,   This field controls the overall operation of the MMU. There are some differences between stage 1 and stage 2.  Execute permissions for a page are evaluated as follows (PTE.&lt;W|R|X> refers to page table entry permissions resolved for hierarchical permissions (if applicable):  EXECUTE_ALLOWED = !((TRANSCFG.WXN &amp; !PTE.W) | (TRANSCFG.XREADABLE &amp; !PTE.R) | (!TRANSCFG.XREADABLE &amp; !PTE.X)) " "LEGACY,UNMAPPED,IDENTITY,3,4,5,AARCH64_4K,7,AARCH64_64K,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--25. "  PTW_MEMATTR            ,   Memory attributes for page table walks. The allowed values are compatible with the values allowed for  MEMORY_TYPE . For outer cache transactions, the desired attributes for the transaction will be decided by the bus master and communicated to the memory system using signals on the bus.  Changed allowed values for TRANSCFG.PTW_MEMATTR. " "0,NON_CACHEABLE,WRITE_BACK,3"
        bitfld.long 0x00 28.--29. "  PTW_SH               ,   This field specifies the shareability for the page table walks. This is the same encoding as used for ARMv8 page tables. " "non_shareable,1,outer_shareable,inner_shareable"
        bitfld.long 0x00 30. "  R_ALLOCATE       ,   This field sets the inner read allocation hint for the page table walks. This is the same encoding as used for ARMv8 page tables. " "no_read_allocate,read_allocate"
        textline "                                     "
        bitfld.long 0x00 22. "SL_CONCAT_EN             ,   If set then the page table walk starting level will be increased if possible by concatenating up to 16 tables in the starting level. " "false,true"

group d:0xC0502434++0x03
    line.long 0x00 "ST1MMUAS0_TRANSCFG_HI,ST1MMUAS0_TRANSCFG_HI"
        bitfld.long 0x00 0. " Res108                   ,Res108" "0,1"
        hexmask.long 0x00 5.--31. 1. "            Res109                 ,Res109"
        bitfld.long 0x00 1. "       DISABLE_HIER_AP      ,   This flag only has an effect on stage 1 of translation. It is ignored for stage 2. Note the inverted logic - the flag must be set to  dis able hierarchical access permissions." "false,true"
        bitfld.long 0x00 2. "            DISABLE_AF_FAULT ,   This flag can be used to disable access fault checking when in one of AARCH64 modes. " "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "WXN                      ,   This flag can be used to disable all writes to executable pages, overriding access permissions specified in the page table. " "false,true"
        bitfld.long 0x00 4. "        XREADABLE              ,   This flag can be used to enable execution on all readable pages, overriding access permissions specified in the page table. " "false,true"

group d:0xC0502438++0x03
    line.long 0x00 "ST1MMUAS0_FAULTEXTRA_LO,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS0FAULTEXTRA_LO   ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "

group d:0xC050243C++0x03
    line.long 0x00 "ST1MMUAS0_FAULTEXTRA_HI,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long.word 0x00 16.--30. 1. " Res110                   ,Res110"
        hexmask.long.word 0x00 0.--15. 1. "         ST1MMUAS0FAULTEXTRA_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "
        bitfld.long 0x00 31. "           S2FS1WALK            ,S2FS1WALK" "stage2,stage1"

width 27.

group d:0xC0502440++0x03
    line.long 0x00 "ST1MMUAS1_TRANSTAB_LO,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        bitfld.long 0x00 0.--3. " Res111                   ,Res111" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long 0x00 4.--31. 1. "           ST1MMUAS1TRANSTAB_LO   ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502444++0x03
    line.long 0x00 "ST1MMUAS1_TRANSTAB_HI,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS1TRANSTAB_HI     ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502448++0x03
    line.long 0x00 "ST1MMUAS1_MEMATTR_LO,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE0               ,   This field specifies the memory attributes for memory type index 0. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE1             ,   This field specifies the memory attributes for memory type index 1. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE2           ,   This field specifies the memory attributes for memory type index 2. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE3       ,   This field specifies the memory attributes for memory type index 3. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE4               ,   This field specifies the memory attributes for memory type index 4. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE5             ,   This field specifies the memory attributes for memory type index 5. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE6           ,   This field specifies the memory attributes for memory type index 6. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE7       ,   This field specifies the memory attributes for memory type index 7. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC050244C++0x03
    line.long 0x00 "ST1MMUAS1_MEMATTR_HI,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE8               ,   This field specifies the memory attributes for memory type index 8. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE9             ,   This field specifies the memory attributes for memory type index 9. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE10          ,   This field specifies the memory attributes for memory type index 10. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE11      ,   This field specifies the memory attributes for memory type index 11. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE12              ,   This field specifies the memory attributes for memory type index 12. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE13            ,   This field specifies the memory attributes for memory type index 13. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE14          ,   This field specifies the memory attributes for memory type index 14. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE15      ,   This field specifies the memory attributes for memory type index 15. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC0502450++0x03
    line.long 0x00 "ST1MMUAS1_LOCKADDR_LO,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long.byte 0x00 6.--11. 1. " Res112                   ,Res112"
        hexmask.long.byte 0x00 0.--5. 1. "           LOCKADDR_SIZE          ,   This field contains the log  2 of the size of the region to lock, minus 1. Only values in the range 11 to 63 are valid values for this field, corresponding to region sizes of 4KB up to the entire address space. Values in the range 0 to 10 result in UNDEFINED behavior and should not be used."
        hexmask.long.tbyte 0x00 12.--31. 1. "             ST1MMUAS1LOCKADDR_LO ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502454++0x03
    line.long 0x00 "ST1MMUAS1_LOCKADDR_HI,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS1LOCKADDR_HI     ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502458++0x03
    line.long 0x00 "ST1MMUAS1_COMMAND,   MMU commands are issued by writing to this register. Any command written to an address space while the corresponding STATUS.AS_ACTIVE flag is set will be ignored.  In general an MMU command only applies to the address space it is submitted to. However a command that invalidates the MMU cache may invalidate the whole MMU cache rather than only those entries specific to one address space. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS1COMMAND         ,ST1MMUAS1COMMAND"

group d:0xC050245C++0x03
    line.long 0x00 "ST1MMUAS1_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.       If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  If the GPU is in protected mode, this register is not updated, and MMU faults are ignored.        They are not fatal but will halt the GPU until the MMU address space is updated.        However, no fault information wil be visible in this case.  Changed access type of MMU_FAULTSTATUS register when in protected mode. "
        hexmask.long.byte 0x00 10.--15. 1. " Res113                   ,Res113"
        hexmask.long.word 0x00 16.--31. 1. "           SOURCE_ID              ,   This field contains an implementation-defined ID that supplies additional data about the source of the fault. For example, it may be the ID of the internal bus master that issued the request that faulted. This makes it possible to distinguish between the job manager, the texture unit and the load/store unit. Another example might be an indication of the type of an invalid data structure. The values in this field are implementation defined. "
        hexmask.long.byte 0x00 0.--7. 1. "           EXCEPTION_TYPE       ,   This field indicates the type of exception that caused the fault. "
        bitfld.long 0x00 8.--9. "               ACCESS_TYPE      ,   This field contains the direction of data transfer that caused the fault, if known.  For the purposes of error reporting, atomic transactions act like a read followed by a write, so denying either permission will result in the atomic transaction failing, and the exceptions ACCESS_TYPE field will be set to 'atomic'. " "atomic,execute:  An execute transaction. ,read:  A read transaction. ,write:  A write transaction. "

group d:0xC0502460++0x03
    line.long 0x00 "ST1MMUAS1_FAULTADDRESS_LO,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS1FAULTADDRESS_LO ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC0502464++0x03
    line.long 0x00 "ST1MMUAS1_FAULTADDRESS_HI,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS1FAULTADDRESS_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC0502468++0x03
    line.long 0x00 "ST1MMUAS1_STATUS,   This register contains dynamic status information about this address space. "
        hexmask.long 0x00 1.--31. 1. " Res114                   ,Res114"
        bitfld.long 0x00 0. "     AS_ACTIVE              ,   This flag is set while a MMU_UPDATE, LOCK, UNLOCK, FLUSH_PT or FLUSH_MEM command is active on this address space. This allows software to safely verify that the address space is in a consistent state after reconfiguring the MMU page tables.  If a new command is written to the corresponding COMMAND register while the AS_ACTIVE bit is set, then the command is ignored. " "false,true"

group d:0xC0502470++0x03
    line.long 0x00 "ST1MMUAS1_TRANSCFG_LO,ST1MMUAS1_TRANSCFG_LO"
        bitfld.long 0x00 4.--5. " Res115                   ,Res115" "0,1,2,3"
        bitfld.long 0x00 11.--13. "            Res116                 ,Res116" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 19.--21. "              Res117               ,Res117" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 23. "                Res118           ,Res118" "0,1"
        textline "                                     "
        bitfld.long 0x00 26.--27. "Res119                   ,Res119" "0,1,2,3"
        bitfld.long 0x00 31. "            Res120                 ,Res120" "0,1"
        bitfld.long 0x00 6.--10. "              INA_BITS             ,   This field allows the system software to restrict the range of input addresses accepted by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  INA_BITS_VALID = min(HW_INA_BITS, 55-INA_BITS)  If the input address is outside the range (0, 2  INA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 14.--18. "               OUTA_BITS        ,   This field allows the system software to restrict the range of output addresses generated by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  OUTA_BITS_VALID = min(HW_OUTA_BITS, 55-OUTA_BITS)  If the translated output address is outside the range (0, 2  OUTA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                     "
        bitfld.long 0x00 0.--3. "MODE                     ,   This field controls the overall operation of the MMU. There are some differences between stage 1 and stage 2.  Execute permissions for a page are evaluated as follows (PTE.&lt;W|R|X> refers to page table entry permissions resolved for hierarchical permissions (if applicable):  EXECUTE_ALLOWED = !((TRANSCFG.WXN &amp; !PTE.W) | (TRANSCFG.XREADABLE &amp; !PTE.R) | (!TRANSCFG.XREADABLE &amp; !PTE.X)) " "LEGACY,UNMAPPED,IDENTITY,3,4,5,AARCH64_4K,7,AARCH64_64K,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--25. "  PTW_MEMATTR            ,   Memory attributes for page table walks. The allowed values are compatible with the values allowed for  MEMORY_TYPE . For outer cache transactions, the desired attributes for the transaction will be decided by the bus master and communicated to the memory system using signals on the bus.  Changed allowed values for TRANSCFG.PTW_MEMATTR. " "0,NON_CACHEABLE,WRITE_BACK,3"
        bitfld.long 0x00 28.--29. "  PTW_SH               ,   This field specifies the shareability for the page table walks. This is the same encoding as used for ARMv8 page tables. " "non_shareable,1,outer_shareable,inner_shareable"
        bitfld.long 0x00 30. "  R_ALLOCATE       ,   This field sets the inner read allocation hint for the page table walks. This is the same encoding as used for ARMv8 page tables. " "no_read_allocate,read_allocate"
        textline "                                     "
        bitfld.long 0x00 22. "SL_CONCAT_EN             ,   If set then the page table walk starting level will be increased if possible by concatenating up to 16 tables in the starting level. " "false,true"

group d:0xC0502474++0x03
    line.long 0x00 "ST1MMUAS1_TRANSCFG_HI,ST1MMUAS1_TRANSCFG_HI"
        bitfld.long 0x00 0. " Res121                   ,Res121" "0,1"
        hexmask.long 0x00 5.--31. 1. "            Res122                 ,Res122"
        bitfld.long 0x00 1. "       DISABLE_HIER_AP      ,   This flag only has an effect on stage 1 of translation. It is ignored for stage 2. Note the inverted logic - the flag must be set to  dis able hierarchical access permissions." "false,true"
        bitfld.long 0x00 2. "            DISABLE_AF_FAULT ,   This flag can be used to disable access fault checking when in one of AARCH64 modes. " "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "WXN                      ,   This flag can be used to disable all writes to executable pages, overriding access permissions specified in the page table. " "false,true"
        bitfld.long 0x00 4. "        XREADABLE              ,   This flag can be used to enable execution on all readable pages, overriding access permissions specified in the page table. " "false,true"

group d:0xC0502478++0x03
    line.long 0x00 "ST1MMUAS1_FAULTEXTRA_LO,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS1FAULTEXTRA_LO   ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "

group d:0xC050247C++0x03
    line.long 0x00 "ST1MMUAS1_FAULTEXTRA_HI,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long.word 0x00 16.--30. 1. " Res123                   ,Res123"
        hexmask.long.word 0x00 0.--15. 1. "         ST1MMUAS1FAULTEXTRA_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "
        bitfld.long 0x00 31. "           S2FS1WALK            ,S2FS1WALK" "stage2,stage1"

width 27.

group d:0xC0502480++0x03
    line.long 0x00 "ST1MMUAS2_TRANSTAB_LO,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        bitfld.long 0x00 0.--3. " Res124                   ,Res124" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long 0x00 4.--31. 1. "           ST1MMUAS2TRANSTAB_LO   ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502484++0x03
    line.long 0x00 "ST1MMUAS2_TRANSTAB_HI,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS2TRANSTAB_HI     ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502488++0x03
    line.long 0x00 "ST1MMUAS2_MEMATTR_LO,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE0               ,   This field specifies the memory attributes for memory type index 0. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE1             ,   This field specifies the memory attributes for memory type index 1. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE2           ,   This field specifies the memory attributes for memory type index 2. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE3       ,   This field specifies the memory attributes for memory type index 3. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE4               ,   This field specifies the memory attributes for memory type index 4. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE5             ,   This field specifies the memory attributes for memory type index 5. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE6           ,   This field specifies the memory attributes for memory type index 6. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE7       ,   This field specifies the memory attributes for memory type index 7. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC050248C++0x03
    line.long 0x00 "ST1MMUAS2_MEMATTR_HI,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE8               ,   This field specifies the memory attributes for memory type index 8. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE9             ,   This field specifies the memory attributes for memory type index 9. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE10          ,   This field specifies the memory attributes for memory type index 10. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE11      ,   This field specifies the memory attributes for memory type index 11. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE12              ,   This field specifies the memory attributes for memory type index 12. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE13            ,   This field specifies the memory attributes for memory type index 13. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE14          ,   This field specifies the memory attributes for memory type index 14. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE15      ,   This field specifies the memory attributes for memory type index 15. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC0502490++0x03
    line.long 0x00 "ST1MMUAS2_LOCKADDR_LO,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long.byte 0x00 6.--11. 1. " Res125                   ,Res125"
        hexmask.long.byte 0x00 0.--5. 1. "           LOCKADDR_SIZE          ,   This field contains the log  2 of the size of the region to lock, minus 1. Only values in the range 11 to 63 are valid values for this field, corresponding to region sizes of 4KB up to the entire address space. Values in the range 0 to 10 result in UNDEFINED behavior and should not be used."
        hexmask.long.tbyte 0x00 12.--31. 1. "             ST1MMUAS2LOCKADDR_LO ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502494++0x03
    line.long 0x00 "ST1MMUAS2_LOCKADDR_HI,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS2LOCKADDR_HI     ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502498++0x03
    line.long 0x00 "ST1MMUAS2_COMMAND,   MMU commands are issued by writing to this register. Any command written to an address space while the corresponding STATUS.AS_ACTIVE flag is set will be ignored.  In general an MMU command only applies to the address space it is submitted to. However a command that invalidates the MMU cache may invalidate the whole MMU cache rather than only those entries specific to one address space. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS2COMMAND         ,ST1MMUAS2COMMAND"

group d:0xC050249C++0x03
    line.long 0x00 "ST1MMUAS2_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.       If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  If the GPU is in protected mode, this register is not updated, and MMU faults are ignored.        They are not fatal but will halt the GPU until the MMU address space is updated.        However, no fault information wil be visible in this case.  Changed access type of MMU_FAULTSTATUS register when in protected mode. "
        hexmask.long.byte 0x00 10.--15. 1. " Res126                   ,Res126"
        hexmask.long.word 0x00 16.--31. 1. "           SOURCE_ID              ,   This field contains an implementation-defined ID that supplies additional data about the source of the fault. For example, it may be the ID of the internal bus master that issued the request that faulted. This makes it possible to distinguish between the job manager, the texture unit and the load/store unit. Another example might be an indication of the type of an invalid data structure. The values in this field are implementation defined. "
        hexmask.long.byte 0x00 0.--7. 1. "           EXCEPTION_TYPE       ,   This field indicates the type of exception that caused the fault. "
        bitfld.long 0x00 8.--9. "               ACCESS_TYPE      ,   This field contains the direction of data transfer that caused the fault, if known.  For the purposes of error reporting, atomic transactions act like a read followed by a write, so denying either permission will result in the atomic transaction failing, and the exceptions ACCESS_TYPE field will be set to 'atomic'. " "atomic,execute:  An execute transaction. ,read:  A read transaction. ,write:  A write transaction. "

group d:0xC05024A0++0x03
    line.long 0x00 "ST1MMUAS2_FAULTADDRESS_LO,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS2FAULTADDRESS_LO ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC05024A4++0x03
    line.long 0x00 "ST1MMUAS2_FAULTADDRESS_HI,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS2FAULTADDRESS_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC05024A8++0x03
    line.long 0x00 "ST1MMUAS2_STATUS,   This register contains dynamic status information about this address space. "
        hexmask.long 0x00 1.--31. 1. " Res127                   ,Res127"
        bitfld.long 0x00 0. "     AS_ACTIVE              ,   This flag is set while a MMU_UPDATE, LOCK, UNLOCK, FLUSH_PT or FLUSH_MEM command is active on this address space. This allows software to safely verify that the address space is in a consistent state after reconfiguring the MMU page tables.  If a new command is written to the corresponding COMMAND register while the AS_ACTIVE bit is set, then the command is ignored. " "false,true"

group d:0xC05024B0++0x03
    line.long 0x00 "ST1MMUAS2_TRANSCFG_LO,ST1MMUAS2_TRANSCFG_LO"
        bitfld.long 0x00 4.--5. " Res128                   ,Res128" "0,1,2,3"
        bitfld.long 0x00 11.--13. "            Res129                 ,Res129" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 19.--21. "              Res130               ,Res130" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 23. "                Res131           ,Res131" "0,1"
        textline "                                     "
        bitfld.long 0x00 26.--27. "Res132                   ,Res132" "0,1,2,3"
        bitfld.long 0x00 31. "            Res133                 ,Res133" "0,1"
        bitfld.long 0x00 6.--10. "              INA_BITS             ,   This field allows the system software to restrict the range of input addresses accepted by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  INA_BITS_VALID = min(HW_INA_BITS, 55-INA_BITS)  If the input address is outside the range (0, 2  INA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 14.--18. "               OUTA_BITS        ,   This field allows the system software to restrict the range of output addresses generated by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  OUTA_BITS_VALID = min(HW_OUTA_BITS, 55-OUTA_BITS)  If the translated output address is outside the range (0, 2  OUTA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                     "
        bitfld.long 0x00 0.--3. "MODE                     ,   This field controls the overall operation of the MMU. There are some differences between stage 1 and stage 2.  Execute permissions for a page are evaluated as follows (PTE.&lt;W|R|X> refers to page table entry permissions resolved for hierarchical permissions (if applicable):  EXECUTE_ALLOWED = !((TRANSCFG.WXN &amp; !PTE.W) | (TRANSCFG.XREADABLE &amp; !PTE.R) | (!TRANSCFG.XREADABLE &amp; !PTE.X)) " "LEGACY,UNMAPPED,IDENTITY,3,4,5,AARCH64_4K,7,AARCH64_64K,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--25. "  PTW_MEMATTR            ,   Memory attributes for page table walks. The allowed values are compatible with the values allowed for  MEMORY_TYPE . For outer cache transactions, the desired attributes for the transaction will be decided by the bus master and communicated to the memory system using signals on the bus.  Changed allowed values for TRANSCFG.PTW_MEMATTR. " "0,NON_CACHEABLE,WRITE_BACK,3"
        bitfld.long 0x00 28.--29. "  PTW_SH               ,   This field specifies the shareability for the page table walks. This is the same encoding as used for ARMv8 page tables. " "non_shareable,1,outer_shareable,inner_shareable"
        bitfld.long 0x00 30. "  R_ALLOCATE       ,   This field sets the inner read allocation hint for the page table walks. This is the same encoding as used for ARMv8 page tables. " "no_read_allocate,read_allocate"
        textline "                                     "
        bitfld.long 0x00 22. "SL_CONCAT_EN             ,   If set then the page table walk starting level will be increased if possible by concatenating up to 16 tables in the starting level. " "false,true"

group d:0xC05024B4++0x03
    line.long 0x00 "ST1MMUAS2_TRANSCFG_HI,ST1MMUAS2_TRANSCFG_HI"
        bitfld.long 0x00 0. " Res134                   ,Res134" "0,1"
        hexmask.long 0x00 5.--31. 1. "            Res135                 ,Res135"
        bitfld.long 0x00 1. "       DISABLE_HIER_AP      ,   This flag only has an effect on stage 1 of translation. It is ignored for stage 2. Note the inverted logic - the flag must be set to  dis able hierarchical access permissions." "false,true"
        bitfld.long 0x00 2. "            DISABLE_AF_FAULT ,   This flag can be used to disable access fault checking when in one of AARCH64 modes. " "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "WXN                      ,   This flag can be used to disable all writes to executable pages, overriding access permissions specified in the page table. " "false,true"
        bitfld.long 0x00 4. "        XREADABLE              ,   This flag can be used to enable execution on all readable pages, overriding access permissions specified in the page table. " "false,true"

group d:0xC05024B8++0x03
    line.long 0x00 "ST1MMUAS2_FAULTEXTRA_LO,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS2FAULTEXTRA_LO   ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "

group d:0xC05024BC++0x03
    line.long 0x00 "ST1MMUAS2_FAULTEXTRA_HI,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long.word 0x00 16.--30. 1. " Res136                   ,Res136"
        hexmask.long.word 0x00 0.--15. 1. "         ST1MMUAS2FAULTEXTRA_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "
        bitfld.long 0x00 31. "           S2FS1WALK            ,S2FS1WALK" "stage2,stage1"

width 27.

group d:0xC05024C0++0x03
    line.long 0x00 "ST1MMUAS3_TRANSTAB_LO,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        bitfld.long 0x00 0.--3. " Res137                   ,Res137" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long 0x00 4.--31. 1. "           ST1MMUAS3TRANSTAB_LO   ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC05024C4++0x03
    line.long 0x00 "ST1MMUAS3_TRANSTAB_HI,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS3TRANSTAB_HI     ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC05024C8++0x03
    line.long 0x00 "ST1MMUAS3_MEMATTR_LO,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE0               ,   This field specifies the memory attributes for memory type index 0. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE1             ,   This field specifies the memory attributes for memory type index 1. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE2           ,   This field specifies the memory attributes for memory type index 2. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE3       ,   This field specifies the memory attributes for memory type index 3. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE4               ,   This field specifies the memory attributes for memory type index 4. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE5             ,   This field specifies the memory attributes for memory type index 5. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE6           ,   This field specifies the memory attributes for memory type index 6. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE7       ,   This field specifies the memory attributes for memory type index 7. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC05024CC++0x03
    line.long 0x00 "ST1MMUAS3_MEMATTR_HI,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE8               ,   This field specifies the memory attributes for memory type index 8. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE9             ,   This field specifies the memory attributes for memory type index 9. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE10          ,   This field specifies the memory attributes for memory type index 10. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE11      ,   This field specifies the memory attributes for memory type index 11. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE12              ,   This field specifies the memory attributes for memory type index 12. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE13            ,   This field specifies the memory attributes for memory type index 13. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE14          ,   This field specifies the memory attributes for memory type index 14. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE15      ,   This field specifies the memory attributes for memory type index 15. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC05024D0++0x03
    line.long 0x00 "ST1MMUAS3_LOCKADDR_LO,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long.byte 0x00 6.--11. 1. " Res138                   ,Res138"
        hexmask.long.byte 0x00 0.--5. 1. "           LOCKADDR_SIZE          ,   This field contains the log  2 of the size of the region to lock, minus 1. Only values in the range 11 to 63 are valid values for this field, corresponding to region sizes of 4KB up to the entire address space. Values in the range 0 to 10 result in UNDEFINED behavior and should not be used."
        hexmask.long.tbyte 0x00 12.--31. 1. "             ST1MMUAS3LOCKADDR_LO ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC05024D4++0x03
    line.long 0x00 "ST1MMUAS3_LOCKADDR_HI,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS3LOCKADDR_HI     ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC05024D8++0x03
    line.long 0x00 "ST1MMUAS3_COMMAND,   MMU commands are issued by writing to this register. Any command written to an address space while the corresponding STATUS.AS_ACTIVE flag is set will be ignored.  In general an MMU command only applies to the address space it is submitted to. However a command that invalidates the MMU cache may invalidate the whole MMU cache rather than only those entries specific to one address space. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS3COMMAND         ,ST1MMUAS3COMMAND"

group d:0xC05024DC++0x03
    line.long 0x00 "ST1MMUAS3_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.       If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  If the GPU is in protected mode, this register is not updated, and MMU faults are ignored.        They are not fatal but will halt the GPU until the MMU address space is updated.        However, no fault information wil be visible in this case.  Changed access type of MMU_FAULTSTATUS register when in protected mode. "
        hexmask.long.byte 0x00 10.--15. 1. " Res139                   ,Res139"
        hexmask.long.word 0x00 16.--31. 1. "           SOURCE_ID              ,   This field contains an implementation-defined ID that supplies additional data about the source of the fault. For example, it may be the ID of the internal bus master that issued the request that faulted. This makes it possible to distinguish between the job manager, the texture unit and the load/store unit. Another example might be an indication of the type of an invalid data structure. The values in this field are implementation defined. "
        hexmask.long.byte 0x00 0.--7. 1. "           EXCEPTION_TYPE       ,   This field indicates the type of exception that caused the fault. "
        bitfld.long 0x00 8.--9. "               ACCESS_TYPE      ,   This field contains the direction of data transfer that caused the fault, if known.  For the purposes of error reporting, atomic transactions act like a read followed by a write, so denying either permission will result in the atomic transaction failing, and the exceptions ACCESS_TYPE field will be set to 'atomic'. " "atomic,execute:  An execute transaction. ,read:  A read transaction. ,write:  A write transaction. "

group d:0xC05024E0++0x03
    line.long 0x00 "ST1MMUAS3_FAULTADDRESS_LO,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS3FAULTADDRESS_LO ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC05024E4++0x03
    line.long 0x00 "ST1MMUAS3_FAULTADDRESS_HI,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS3FAULTADDRESS_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC05024E8++0x03
    line.long 0x00 "ST1MMUAS3_STATUS,   This register contains dynamic status information about this address space. "
        hexmask.long 0x00 1.--31. 1. " Res140                   ,Res140"
        bitfld.long 0x00 0. "     AS_ACTIVE              ,   This flag is set while a MMU_UPDATE, LOCK, UNLOCK, FLUSH_PT or FLUSH_MEM command is active on this address space. This allows software to safely verify that the address space is in a consistent state after reconfiguring the MMU page tables.  If a new command is written to the corresponding COMMAND register while the AS_ACTIVE bit is set, then the command is ignored. " "false,true"

group d:0xC05024F0++0x03
    line.long 0x00 "ST1MMUAS3_TRANSCFG_LO,ST1MMUAS3_TRANSCFG_LO"
        bitfld.long 0x00 4.--5. " Res141                   ,Res141" "0,1,2,3"
        bitfld.long 0x00 11.--13. "            Res142                 ,Res142" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 19.--21. "              Res143               ,Res143" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 23. "                Res144           ,Res144" "0,1"
        textline "                                     "
        bitfld.long 0x00 26.--27. "Res145                   ,Res145" "0,1,2,3"
        bitfld.long 0x00 31. "            Res146                 ,Res146" "0,1"
        bitfld.long 0x00 6.--10. "              INA_BITS             ,   This field allows the system software to restrict the range of input addresses accepted by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  INA_BITS_VALID = min(HW_INA_BITS, 55-INA_BITS)  If the input address is outside the range (0, 2  INA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 14.--18. "               OUTA_BITS        ,   This field allows the system software to restrict the range of output addresses generated by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  OUTA_BITS_VALID = min(HW_OUTA_BITS, 55-OUTA_BITS)  If the translated output address is outside the range (0, 2  OUTA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                     "
        bitfld.long 0x00 0.--3. "MODE                     ,   This field controls the overall operation of the MMU. There are some differences between stage 1 and stage 2.  Execute permissions for a page are evaluated as follows (PTE.&lt;W|R|X> refers to page table entry permissions resolved for hierarchical permissions (if applicable):  EXECUTE_ALLOWED = !((TRANSCFG.WXN &amp; !PTE.W) | (TRANSCFG.XREADABLE &amp; !PTE.R) | (!TRANSCFG.XREADABLE &amp; !PTE.X)) " "LEGACY,UNMAPPED,IDENTITY,3,4,5,AARCH64_4K,7,AARCH64_64K,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--25. "  PTW_MEMATTR            ,   Memory attributes for page table walks. The allowed values are compatible with the values allowed for  MEMORY_TYPE . For outer cache transactions, the desired attributes for the transaction will be decided by the bus master and communicated to the memory system using signals on the bus.  Changed allowed values for TRANSCFG.PTW_MEMATTR. " "0,NON_CACHEABLE,WRITE_BACK,3"
        bitfld.long 0x00 28.--29. "  PTW_SH               ,   This field specifies the shareability for the page table walks. This is the same encoding as used for ARMv8 page tables. " "non_shareable,1,outer_shareable,inner_shareable"
        bitfld.long 0x00 30. "  R_ALLOCATE       ,   This field sets the inner read allocation hint for the page table walks. This is the same encoding as used for ARMv8 page tables. " "no_read_allocate,read_allocate"
        textline "                                     "
        bitfld.long 0x00 22. "SL_CONCAT_EN             ,   If set then the page table walk starting level will be increased if possible by concatenating up to 16 tables in the starting level. " "false,true"

group d:0xC05024F4++0x03
    line.long 0x00 "ST1MMUAS3_TRANSCFG_HI,ST1MMUAS3_TRANSCFG_HI"
        bitfld.long 0x00 0. " Res147                   ,Res147" "0,1"
        hexmask.long 0x00 5.--31. 1. "            Res148                 ,Res148"
        bitfld.long 0x00 1. "       DISABLE_HIER_AP      ,   This flag only has an effect on stage 1 of translation. It is ignored for stage 2. Note the inverted logic - the flag must be set to  dis able hierarchical access permissions." "false,true"
        bitfld.long 0x00 2. "            DISABLE_AF_FAULT ,   This flag can be used to disable access fault checking when in one of AARCH64 modes. " "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "WXN                      ,   This flag can be used to disable all writes to executable pages, overriding access permissions specified in the page table. " "false,true"
        bitfld.long 0x00 4. "        XREADABLE              ,   This flag can be used to enable execution on all readable pages, overriding access permissions specified in the page table. " "false,true"

group d:0xC05024F8++0x03
    line.long 0x00 "ST1MMUAS3_FAULTEXTRA_LO,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS3FAULTEXTRA_LO   ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "

group d:0xC05024FC++0x03
    line.long 0x00 "ST1MMUAS3_FAULTEXTRA_HI,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long.word 0x00 16.--30. 1. " Res149                   ,Res149"
        hexmask.long.word 0x00 0.--15. 1. "         ST1MMUAS3FAULTEXTRA_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "
        bitfld.long 0x00 31. "           S2FS1WALK            ,S2FS1WALK" "stage2,stage1"

width 27.

group d:0xC0502500++0x03
    line.long 0x00 "ST1MMUAS4_TRANSTAB_LO,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        bitfld.long 0x00 0.--3. " Res150                   ,Res150" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long 0x00 4.--31. 1. "           ST1MMUAS4TRANSTAB_LO   ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502504++0x03
    line.long 0x00 "ST1MMUAS4_TRANSTAB_HI,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS4TRANSTAB_HI     ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502508++0x03
    line.long 0x00 "ST1MMUAS4_MEMATTR_LO,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE0               ,   This field specifies the memory attributes for memory type index 0. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE1             ,   This field specifies the memory attributes for memory type index 1. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE2           ,   This field specifies the memory attributes for memory type index 2. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE3       ,   This field specifies the memory attributes for memory type index 3. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE4               ,   This field specifies the memory attributes for memory type index 4. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE5             ,   This field specifies the memory attributes for memory type index 5. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE6           ,   This field specifies the memory attributes for memory type index 6. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE7       ,   This field specifies the memory attributes for memory type index 7. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC050250C++0x03
    line.long 0x00 "ST1MMUAS4_MEMATTR_HI,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE8               ,   This field specifies the memory attributes for memory type index 8. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE9             ,   This field specifies the memory attributes for memory type index 9. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE10          ,   This field specifies the memory attributes for memory type index 10. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE11      ,   This field specifies the memory attributes for memory type index 11. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE12              ,   This field specifies the memory attributes for memory type index 12. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE13            ,   This field specifies the memory attributes for memory type index 13. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE14          ,   This field specifies the memory attributes for memory type index 14. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE15      ,   This field specifies the memory attributes for memory type index 15. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC0502510++0x03
    line.long 0x00 "ST1MMUAS4_LOCKADDR_LO,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long.byte 0x00 6.--11. 1. " Res151                   ,Res151"
        hexmask.long.byte 0x00 0.--5. 1. "           LOCKADDR_SIZE          ,   This field contains the log  2 of the size of the region to lock, minus 1. Only values in the range 11 to 63 are valid values for this field, corresponding to region sizes of 4KB up to the entire address space. Values in the range 0 to 10 result in UNDEFINED behavior and should not be used."
        hexmask.long.tbyte 0x00 12.--31. 1. "             ST1MMUAS4LOCKADDR_LO ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502514++0x03
    line.long 0x00 "ST1MMUAS4_LOCKADDR_HI,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS4LOCKADDR_HI     ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502518++0x03
    line.long 0x00 "ST1MMUAS4_COMMAND,   MMU commands are issued by writing to this register. Any command written to an address space while the corresponding STATUS.AS_ACTIVE flag is set will be ignored.  In general an MMU command only applies to the address space it is submitted to. However a command that invalidates the MMU cache may invalidate the whole MMU cache rather than only those entries specific to one address space. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS4COMMAND         ,ST1MMUAS4COMMAND"

group d:0xC050251C++0x03
    line.long 0x00 "ST1MMUAS4_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.       If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  If the GPU is in protected mode, this register is not updated, and MMU faults are ignored.        They are not fatal but will halt the GPU until the MMU address space is updated.        However, no fault information wil be visible in this case.  Changed access type of MMU_FAULTSTATUS register when in protected mode. "
        hexmask.long.byte 0x00 10.--15. 1. " Res152                   ,Res152"
        hexmask.long.word 0x00 16.--31. 1. "           SOURCE_ID              ,   This field contains an implementation-defined ID that supplies additional data about the source of the fault. For example, it may be the ID of the internal bus master that issued the request that faulted. This makes it possible to distinguish between the job manager, the texture unit and the load/store unit. Another example might be an indication of the type of an invalid data structure. The values in this field are implementation defined. "
        hexmask.long.byte 0x00 0.--7. 1. "           EXCEPTION_TYPE       ,   This field indicates the type of exception that caused the fault. "
        bitfld.long 0x00 8.--9. "               ACCESS_TYPE      ,   This field contains the direction of data transfer that caused the fault, if known.  For the purposes of error reporting, atomic transactions act like a read followed by a write, so denying either permission will result in the atomic transaction failing, and the exceptions ACCESS_TYPE field will be set to 'atomic'. " "atomic,execute:  An execute transaction. ,read:  A read transaction. ,write:  A write transaction. "

group d:0xC0502520++0x03
    line.long 0x00 "ST1MMUAS4_FAULTADDRESS_LO,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS4FAULTADDRESS_LO ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC0502524++0x03
    line.long 0x00 "ST1MMUAS4_FAULTADDRESS_HI,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS4FAULTADDRESS_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC0502528++0x03
    line.long 0x00 "ST1MMUAS4_STATUS,   This register contains dynamic status information about this address space. "
        hexmask.long 0x00 1.--31. 1. " Res153                   ,Res153"
        bitfld.long 0x00 0. "     AS_ACTIVE              ,   This flag is set while a MMU_UPDATE, LOCK, UNLOCK, FLUSH_PT or FLUSH_MEM command is active on this address space. This allows software to safely verify that the address space is in a consistent state after reconfiguring the MMU page tables.  If a new command is written to the corresponding COMMAND register while the AS_ACTIVE bit is set, then the command is ignored. " "false,true"

group d:0xC0502530++0x03
    line.long 0x00 "ST1MMUAS4_TRANSCFG_LO,ST1MMUAS4_TRANSCFG_LO"
        bitfld.long 0x00 4.--5. " Res154                   ,Res154" "0,1,2,3"
        bitfld.long 0x00 11.--13. "            Res155                 ,Res155" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 19.--21. "              Res156               ,Res156" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 23. "                Res157           ,Res157" "0,1"
        textline "                                     "
        bitfld.long 0x00 26.--27. "Res158                   ,Res158" "0,1,2,3"
        bitfld.long 0x00 31. "            Res159                 ,Res159" "0,1"
        bitfld.long 0x00 6.--10. "              INA_BITS             ,   This field allows the system software to restrict the range of input addresses accepted by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  INA_BITS_VALID = min(HW_INA_BITS, 55-INA_BITS)  If the input address is outside the range (0, 2  INA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 14.--18. "               OUTA_BITS        ,   This field allows the system software to restrict the range of output addresses generated by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  OUTA_BITS_VALID = min(HW_OUTA_BITS, 55-OUTA_BITS)  If the translated output address is outside the range (0, 2  OUTA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                     "
        bitfld.long 0x00 0.--3. "MODE                     ,   This field controls the overall operation of the MMU. There are some differences between stage 1 and stage 2.  Execute permissions for a page are evaluated as follows (PTE.&lt;W|R|X> refers to page table entry permissions resolved for hierarchical permissions (if applicable):  EXECUTE_ALLOWED = !((TRANSCFG.WXN &amp; !PTE.W) | (TRANSCFG.XREADABLE &amp; !PTE.R) | (!TRANSCFG.XREADABLE &amp; !PTE.X)) " "LEGACY,UNMAPPED,IDENTITY,3,4,5,AARCH64_4K,7,AARCH64_64K,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--25. "  PTW_MEMATTR            ,   Memory attributes for page table walks. The allowed values are compatible with the values allowed for  MEMORY_TYPE . For outer cache transactions, the desired attributes for the transaction will be decided by the bus master and communicated to the memory system using signals on the bus.  Changed allowed values for TRANSCFG.PTW_MEMATTR. " "0,NON_CACHEABLE,WRITE_BACK,3"
        bitfld.long 0x00 28.--29. "  PTW_SH               ,   This field specifies the shareability for the page table walks. This is the same encoding as used for ARMv8 page tables. " "non_shareable,1,outer_shareable,inner_shareable"
        bitfld.long 0x00 30. "  R_ALLOCATE       ,   This field sets the inner read allocation hint for the page table walks. This is the same encoding as used for ARMv8 page tables. " "no_read_allocate,read_allocate"
        textline "                                     "
        bitfld.long 0x00 22. "SL_CONCAT_EN             ,   If set then the page table walk starting level will be increased if possible by concatenating up to 16 tables in the starting level. " "false,true"

group d:0xC0502534++0x03
    line.long 0x00 "ST1MMUAS4_TRANSCFG_HI,ST1MMUAS4_TRANSCFG_HI"
        bitfld.long 0x00 0. " Res160                   ,Res160" "0,1"
        hexmask.long 0x00 5.--31. 1. "            Res161                 ,Res161"
        bitfld.long 0x00 1. "       DISABLE_HIER_AP      ,   This flag only has an effect on stage 1 of translation. It is ignored for stage 2. Note the inverted logic - the flag must be set to  dis able hierarchical access permissions." "false,true"
        bitfld.long 0x00 2. "            DISABLE_AF_FAULT ,   This flag can be used to disable access fault checking when in one of AARCH64 modes. " "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "WXN                      ,   This flag can be used to disable all writes to executable pages, overriding access permissions specified in the page table. " "false,true"
        bitfld.long 0x00 4. "        XREADABLE              ,   This flag can be used to enable execution on all readable pages, overriding access permissions specified in the page table. " "false,true"

group d:0xC0502538++0x03
    line.long 0x00 "ST1MMUAS4_FAULTEXTRA_LO,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS4FAULTEXTRA_LO   ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "

group d:0xC050253C++0x03
    line.long 0x00 "ST1MMUAS4_FAULTEXTRA_HI,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long.word 0x00 16.--30. 1. " Res162                   ,Res162"
        hexmask.long.word 0x00 0.--15. 1. "         ST1MMUAS4FAULTEXTRA_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "
        bitfld.long 0x00 31. "           S2FS1WALK            ,S2FS1WALK" "stage2,stage1"

width 27.

group d:0xC0502540++0x03
    line.long 0x00 "ST1MMUAS5_TRANSTAB_LO,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        bitfld.long 0x00 0.--3. " Res163                   ,Res163" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long 0x00 4.--31. 1. "           ST1MMUAS5TRANSTAB_LO   ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502544++0x03
    line.long 0x00 "ST1MMUAS5_TRANSTAB_HI,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS5TRANSTAB_HI     ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502548++0x03
    line.long 0x00 "ST1MMUAS5_MEMATTR_LO,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE0               ,   This field specifies the memory attributes for memory type index 0. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE1             ,   This field specifies the memory attributes for memory type index 1. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE2           ,   This field specifies the memory attributes for memory type index 2. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE3       ,   This field specifies the memory attributes for memory type index 3. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE4               ,   This field specifies the memory attributes for memory type index 4. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE5             ,   This field specifies the memory attributes for memory type index 5. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE6           ,   This field specifies the memory attributes for memory type index 6. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE7       ,   This field specifies the memory attributes for memory type index 7. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC050254C++0x03
    line.long 0x00 "ST1MMUAS5_MEMATTR_HI,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE8               ,   This field specifies the memory attributes for memory type index 8. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE9             ,   This field specifies the memory attributes for memory type index 9. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE10          ,   This field specifies the memory attributes for memory type index 10. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE11      ,   This field specifies the memory attributes for memory type index 11. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE12              ,   This field specifies the memory attributes for memory type index 12. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE13            ,   This field specifies the memory attributes for memory type index 13. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE14          ,   This field specifies the memory attributes for memory type index 14. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE15      ,   This field specifies the memory attributes for memory type index 15. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC0502550++0x03
    line.long 0x00 "ST1MMUAS5_LOCKADDR_LO,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long.byte 0x00 6.--11. 1. " Res164                   ,Res164"
        hexmask.long.byte 0x00 0.--5. 1. "           LOCKADDR_SIZE          ,   This field contains the log  2 of the size of the region to lock, minus 1. Only values in the range 11 to 63 are valid values for this field, corresponding to region sizes of 4KB up to the entire address space. Values in the range 0 to 10 result in UNDEFINED behavior and should not be used."
        hexmask.long.tbyte 0x00 12.--31. 1. "             ST1MMUAS5LOCKADDR_LO ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502554++0x03
    line.long 0x00 "ST1MMUAS5_LOCKADDR_HI,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS5LOCKADDR_HI     ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502558++0x03
    line.long 0x00 "ST1MMUAS5_COMMAND,   MMU commands are issued by writing to this register. Any command written to an address space while the corresponding STATUS.AS_ACTIVE flag is set will be ignored.  In general an MMU command only applies to the address space it is submitted to. However a command that invalidates the MMU cache may invalidate the whole MMU cache rather than only those entries specific to one address space. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS5COMMAND         ,ST1MMUAS5COMMAND"

group d:0xC050255C++0x03
    line.long 0x00 "ST1MMUAS5_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.       If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  If the GPU is in protected mode, this register is not updated, and MMU faults are ignored.        They are not fatal but will halt the GPU until the MMU address space is updated.        However, no fault information wil be visible in this case.  Changed access type of MMU_FAULTSTATUS register when in protected mode. "
        hexmask.long.byte 0x00 10.--15. 1. " Res165                   ,Res165"
        hexmask.long.word 0x00 16.--31. 1. "           SOURCE_ID              ,   This field contains an implementation-defined ID that supplies additional data about the source of the fault. For example, it may be the ID of the internal bus master that issued the request that faulted. This makes it possible to distinguish between the job manager, the texture unit and the load/store unit. Another example might be an indication of the type of an invalid data structure. The values in this field are implementation defined. "
        hexmask.long.byte 0x00 0.--7. 1. "           EXCEPTION_TYPE       ,   This field indicates the type of exception that caused the fault. "
        bitfld.long 0x00 8.--9. "               ACCESS_TYPE      ,   This field contains the direction of data transfer that caused the fault, if known.  For the purposes of error reporting, atomic transactions act like a read followed by a write, so denying either permission will result in the atomic transaction failing, and the exceptions ACCESS_TYPE field will be set to 'atomic'. " "atomic,execute:  An execute transaction. ,read:  A read transaction. ,write:  A write transaction. "

group d:0xC0502560++0x03
    line.long 0x00 "ST1MMUAS5_FAULTADDRESS_LO,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS5FAULTADDRESS_LO ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC0502564++0x03
    line.long 0x00 "ST1MMUAS5_FAULTADDRESS_HI,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS5FAULTADDRESS_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC0502568++0x03
    line.long 0x00 "ST1MMUAS5_STATUS,   This register contains dynamic status information about this address space. "
        hexmask.long 0x00 1.--31. 1. " Res166                   ,Res166"
        bitfld.long 0x00 0. "     AS_ACTIVE              ,   This flag is set while a MMU_UPDATE, LOCK, UNLOCK, FLUSH_PT or FLUSH_MEM command is active on this address space. This allows software to safely verify that the address space is in a consistent state after reconfiguring the MMU page tables.  If a new command is written to the corresponding COMMAND register while the AS_ACTIVE bit is set, then the command is ignored. " "false,true"

group d:0xC0502570++0x03
    line.long 0x00 "ST1MMUAS5_TRANSCFG_LO,ST1MMUAS5_TRANSCFG_LO"
        bitfld.long 0x00 4.--5. " Res167                   ,Res167" "0,1,2,3"
        bitfld.long 0x00 11.--13. "            Res168                 ,Res168" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 19.--21. "              Res169               ,Res169" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 23. "                Res170           ,Res170" "0,1"
        textline "                                     "
        bitfld.long 0x00 26.--27. "Res171                   ,Res171" "0,1,2,3"
        bitfld.long 0x00 31. "            Res172                 ,Res172" "0,1"
        bitfld.long 0x00 6.--10. "              INA_BITS             ,   This field allows the system software to restrict the range of input addresses accepted by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  INA_BITS_VALID = min(HW_INA_BITS, 55-INA_BITS)  If the input address is outside the range (0, 2  INA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 14.--18. "               OUTA_BITS        ,   This field allows the system software to restrict the range of output addresses generated by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  OUTA_BITS_VALID = min(HW_OUTA_BITS, 55-OUTA_BITS)  If the translated output address is outside the range (0, 2  OUTA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                     "
        bitfld.long 0x00 0.--3. "MODE                     ,   This field controls the overall operation of the MMU. There are some differences between stage 1 and stage 2.  Execute permissions for a page are evaluated as follows (PTE.&lt;W|R|X> refers to page table entry permissions resolved for hierarchical permissions (if applicable):  EXECUTE_ALLOWED = !((TRANSCFG.WXN &amp; !PTE.W) | (TRANSCFG.XREADABLE &amp; !PTE.R) | (!TRANSCFG.XREADABLE &amp; !PTE.X)) " "LEGACY,UNMAPPED,IDENTITY,3,4,5,AARCH64_4K,7,AARCH64_64K,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--25. "  PTW_MEMATTR            ,   Memory attributes for page table walks. The allowed values are compatible with the values allowed for  MEMORY_TYPE . For outer cache transactions, the desired attributes for the transaction will be decided by the bus master and communicated to the memory system using signals on the bus.  Changed allowed values for TRANSCFG.PTW_MEMATTR. " "0,NON_CACHEABLE,WRITE_BACK,3"
        bitfld.long 0x00 28.--29. "  PTW_SH               ,   This field specifies the shareability for the page table walks. This is the same encoding as used for ARMv8 page tables. " "non_shareable,1,outer_shareable,inner_shareable"
        bitfld.long 0x00 30. "  R_ALLOCATE       ,   This field sets the inner read allocation hint for the page table walks. This is the same encoding as used for ARMv8 page tables. " "no_read_allocate,read_allocate"
        textline "                                     "
        bitfld.long 0x00 22. "SL_CONCAT_EN             ,   If set then the page table walk starting level will be increased if possible by concatenating up to 16 tables in the starting level. " "false,true"

group d:0xC0502574++0x03
    line.long 0x00 "ST1MMUAS5_TRANSCFG_HI,ST1MMUAS5_TRANSCFG_HI"
        bitfld.long 0x00 0. " Res173                   ,Res173" "0,1"
        hexmask.long 0x00 5.--31. 1. "            Res174                 ,Res174"
        bitfld.long 0x00 1. "       DISABLE_HIER_AP      ,   This flag only has an effect on stage 1 of translation. It is ignored for stage 2. Note the inverted logic - the flag must be set to  dis able hierarchical access permissions." "false,true"
        bitfld.long 0x00 2. "            DISABLE_AF_FAULT ,   This flag can be used to disable access fault checking when in one of AARCH64 modes. " "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "WXN                      ,   This flag can be used to disable all writes to executable pages, overriding access permissions specified in the page table. " "false,true"
        bitfld.long 0x00 4. "        XREADABLE              ,   This flag can be used to enable execution on all readable pages, overriding access permissions specified in the page table. " "false,true"

group d:0xC0502578++0x03
    line.long 0x00 "ST1MMUAS5_FAULTEXTRA_LO,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS5FAULTEXTRA_LO   ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "

group d:0xC050257C++0x03
    line.long 0x00 "ST1MMUAS5_FAULTEXTRA_HI,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long.word 0x00 16.--30. 1. " Res175                   ,Res175"
        hexmask.long.word 0x00 0.--15. 1. "         ST1MMUAS5FAULTEXTRA_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "
        bitfld.long 0x00 31. "           S2FS1WALK            ,S2FS1WALK" "stage2,stage1"

width 27.

group d:0xC0502580++0x03
    line.long 0x00 "ST1MMUAS6_TRANSTAB_LO,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        bitfld.long 0x00 0.--3. " Res176                   ,Res176" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long 0x00 4.--31. 1. "           ST1MMUAS6TRANSTAB_LO   ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502584++0x03
    line.long 0x00 "ST1MMUAS6_TRANSTAB_HI,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS6TRANSTAB_HI     ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC0502588++0x03
    line.long 0x00 "ST1MMUAS6_MEMATTR_LO,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE0               ,   This field specifies the memory attributes for memory type index 0. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE1             ,   This field specifies the memory attributes for memory type index 1. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE2           ,   This field specifies the memory attributes for memory type index 2. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE3       ,   This field specifies the memory attributes for memory type index 3. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE4               ,   This field specifies the memory attributes for memory type index 4. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE5             ,   This field specifies the memory attributes for memory type index 5. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE6           ,   This field specifies the memory attributes for memory type index 6. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE7       ,   This field specifies the memory attributes for memory type index 7. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC050258C++0x03
    line.long 0x00 "ST1MMUAS6_MEMATTR_HI,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE8               ,   This field specifies the memory attributes for memory type index 8. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE9             ,   This field specifies the memory attributes for memory type index 9. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE10          ,   This field specifies the memory attributes for memory type index 10. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE11      ,   This field specifies the memory attributes for memory type index 11. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE12              ,   This field specifies the memory attributes for memory type index 12. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE13            ,   This field specifies the memory attributes for memory type index 13. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE14          ,   This field specifies the memory attributes for memory type index 14. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE15      ,   This field specifies the memory attributes for memory type index 15. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC0502590++0x03
    line.long 0x00 "ST1MMUAS6_LOCKADDR_LO,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long.byte 0x00 6.--11. 1. " Res177                   ,Res177"
        hexmask.long.byte 0x00 0.--5. 1. "           LOCKADDR_SIZE          ,   This field contains the log  2 of the size of the region to lock, minus 1. Only values in the range 11 to 63 are valid values for this field, corresponding to region sizes of 4KB up to the entire address space. Values in the range 0 to 10 result in UNDEFINED behavior and should not be used."
        hexmask.long.tbyte 0x00 12.--31. 1. "             ST1MMUAS6LOCKADDR_LO ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502594++0x03
    line.long 0x00 "ST1MMUAS6_LOCKADDR_HI,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS6LOCKADDR_HI     ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC0502598++0x03
    line.long 0x00 "ST1MMUAS6_COMMAND,   MMU commands are issued by writing to this register. Any command written to an address space while the corresponding STATUS.AS_ACTIVE flag is set will be ignored.  In general an MMU command only applies to the address space it is submitted to. However a command that invalidates the MMU cache may invalidate the whole MMU cache rather than only those entries specific to one address space. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS6COMMAND         ,ST1MMUAS6COMMAND"

group d:0xC050259C++0x03
    line.long 0x00 "ST1MMUAS6_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.       If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  If the GPU is in protected mode, this register is not updated, and MMU faults are ignored.        They are not fatal but will halt the GPU until the MMU address space is updated.        However, no fault information wil be visible in this case.  Changed access type of MMU_FAULTSTATUS register when in protected mode. "
        hexmask.long.byte 0x00 10.--15. 1. " Res178                   ,Res178"
        hexmask.long.word 0x00 16.--31. 1. "           SOURCE_ID              ,   This field contains an implementation-defined ID that supplies additional data about the source of the fault. For example, it may be the ID of the internal bus master that issued the request that faulted. This makes it possible to distinguish between the job manager, the texture unit and the load/store unit. Another example might be an indication of the type of an invalid data structure. The values in this field are implementation defined. "
        hexmask.long.byte 0x00 0.--7. 1. "           EXCEPTION_TYPE       ,   This field indicates the type of exception that caused the fault. "
        bitfld.long 0x00 8.--9. "               ACCESS_TYPE      ,   This field contains the direction of data transfer that caused the fault, if known.  For the purposes of error reporting, atomic transactions act like a read followed by a write, so denying either permission will result in the atomic transaction failing, and the exceptions ACCESS_TYPE field will be set to 'atomic'. " "atomic,execute:  An execute transaction. ,read:  A read transaction. ,write:  A write transaction. "

group d:0xC05025A0++0x03
    line.long 0x00 "ST1MMUAS6_FAULTADDRESS_LO,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS6FAULTADDRESS_LO ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC05025A4++0x03
    line.long 0x00 "ST1MMUAS6_FAULTADDRESS_HI,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS6FAULTADDRESS_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC05025A8++0x03
    line.long 0x00 "ST1MMUAS6_STATUS,   This register contains dynamic status information about this address space. "
        hexmask.long 0x00 1.--31. 1. " Res179                   ,Res179"
        bitfld.long 0x00 0. "     AS_ACTIVE              ,   This flag is set while a MMU_UPDATE, LOCK, UNLOCK, FLUSH_PT or FLUSH_MEM command is active on this address space. This allows software to safely verify that the address space is in a consistent state after reconfiguring the MMU page tables.  If a new command is written to the corresponding COMMAND register while the AS_ACTIVE bit is set, then the command is ignored. " "false,true"

group d:0xC05025B0++0x03
    line.long 0x00 "ST1MMUAS6_TRANSCFG_LO,ST1MMUAS6_TRANSCFG_LO"
        bitfld.long 0x00 4.--5. " Res180                   ,Res180" "0,1,2,3"
        bitfld.long 0x00 11.--13. "            Res181                 ,Res181" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 19.--21. "              Res182               ,Res182" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 23. "                Res183           ,Res183" "0,1"
        textline "                                     "
        bitfld.long 0x00 26.--27. "Res184                   ,Res184" "0,1,2,3"
        bitfld.long 0x00 31. "            Res185                 ,Res185" "0,1"
        bitfld.long 0x00 6.--10. "              INA_BITS             ,   This field allows the system software to restrict the range of input addresses accepted by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  INA_BITS_VALID = min(HW_INA_BITS, 55-INA_BITS)  If the input address is outside the range (0, 2  INA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 14.--18. "               OUTA_BITS        ,   This field allows the system software to restrict the range of output addresses generated by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  OUTA_BITS_VALID = min(HW_OUTA_BITS, 55-OUTA_BITS)  If the translated output address is outside the range (0, 2  OUTA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                     "
        bitfld.long 0x00 0.--3. "MODE                     ,   This field controls the overall operation of the MMU. There are some differences between stage 1 and stage 2.  Execute permissions for a page are evaluated as follows (PTE.&lt;W|R|X> refers to page table entry permissions resolved for hierarchical permissions (if applicable):  EXECUTE_ALLOWED = !((TRANSCFG.WXN &amp; !PTE.W) | (TRANSCFG.XREADABLE &amp; !PTE.R) | (!TRANSCFG.XREADABLE &amp; !PTE.X)) " "LEGACY,UNMAPPED,IDENTITY,3,4,5,AARCH64_4K,7,AARCH64_64K,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--25. "  PTW_MEMATTR            ,   Memory attributes for page table walks. The allowed values are compatible with the values allowed for  MEMORY_TYPE . For outer cache transactions, the desired attributes for the transaction will be decided by the bus master and communicated to the memory system using signals on the bus.  Changed allowed values for TRANSCFG.PTW_MEMATTR. " "0,NON_CACHEABLE,WRITE_BACK,3"
        bitfld.long 0x00 28.--29. "  PTW_SH               ,   This field specifies the shareability for the page table walks. This is the same encoding as used for ARMv8 page tables. " "non_shareable,1,outer_shareable,inner_shareable"
        bitfld.long 0x00 30. "  R_ALLOCATE       ,   This field sets the inner read allocation hint for the page table walks. This is the same encoding as used for ARMv8 page tables. " "no_read_allocate,read_allocate"
        textline "                                     "
        bitfld.long 0x00 22. "SL_CONCAT_EN             ,   If set then the page table walk starting level will be increased if possible by concatenating up to 16 tables in the starting level. " "false,true"

group d:0xC05025B4++0x03
    line.long 0x00 "ST1MMUAS6_TRANSCFG_HI,ST1MMUAS6_TRANSCFG_HI"
        bitfld.long 0x00 0. " Res186                   ,Res186" "0,1"
        hexmask.long 0x00 5.--31. 1. "            Res187                 ,Res187"
        bitfld.long 0x00 1. "       DISABLE_HIER_AP      ,   This flag only has an effect on stage 1 of translation. It is ignored for stage 2. Note the inverted logic - the flag must be set to  dis able hierarchical access permissions." "false,true"
        bitfld.long 0x00 2. "            DISABLE_AF_FAULT ,   This flag can be used to disable access fault checking when in one of AARCH64 modes. " "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "WXN                      ,   This flag can be used to disable all writes to executable pages, overriding access permissions specified in the page table. " "false,true"
        bitfld.long 0x00 4. "        XREADABLE              ,   This flag can be used to enable execution on all readable pages, overriding access permissions specified in the page table. " "false,true"

group d:0xC05025B8++0x03
    line.long 0x00 "ST1MMUAS6_FAULTEXTRA_LO,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS6FAULTEXTRA_LO   ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "

group d:0xC05025BC++0x03
    line.long 0x00 "ST1MMUAS6_FAULTEXTRA_HI,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long.word 0x00 16.--30. 1. " Res188                   ,Res188"
        hexmask.long.word 0x00 0.--15. 1. "         ST1MMUAS6FAULTEXTRA_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "
        bitfld.long 0x00 31. "           S2FS1WALK            ,S2FS1WALK" "stage2,stage1"

width 27.

group d:0xC05025C0++0x03
    line.long 0x00 "ST1MMUAS7_TRANSTAB_LO,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        bitfld.long 0x00 0.--3. " Res189                   ,Res189" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long 0x00 4.--31. 1. "           ST1MMUAS7TRANSTAB_LO   ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC05025C4++0x03
    line.long 0x00 "ST1MMUAS7_TRANSTAB_HI,   This register contains the address of the base level of the translation table, together with some related flags.  Details on the layout of the page tables, and the address translation process, can be found in the section  Memory Management Unit ."
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS7TRANSTAB_HI     ,   This field contains the address of the top level of a page table structure. This must be 16-byte-aligned, so address bits [3:0] are assumed to be zero.  For a stage 1 page table, this will be an intermediate physical address, and for stage 2 it will be a physical address. The number of actual translated address bits is stored in  OUTA_BITS . The unused high bits must be set to 0. Changed alignment text for TRANSTAB.BASE  TRANSTAB.BASE pointer is a physical (or intermediate) address "

group d:0xC05025C8++0x03
    line.long 0x00 "ST1MMUAS7_MEMATTR_LO,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE0               ,   This field specifies the memory attributes for memory type index 0. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE1             ,   This field specifies the memory attributes for memory type index 1. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE2           ,   This field specifies the memory attributes for memory type index 2. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE3       ,   This field specifies the memory attributes for memory type index 3. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE4               ,   This field specifies the memory attributes for memory type index 4. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE5             ,   This field specifies the memory attributes for memory type index 5. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE6           ,   This field specifies the memory attributes for memory type index 6. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE7       ,   This field specifies the memory attributes for memory type index 7. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC05025CC++0x03
    line.long 0x00 "ST1MMUAS7_MEMATTR_HI,"
        bitfld.long 0x00 0.--3. " ATTRIBUTE8               ,   This field specifies the memory attributes for memory type index 8. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "       ATTRIBUTE9             ,   This field specifies the memory attributes for memory type index 9. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "         ATTRIBUTE10          ,   This field specifies the memory attributes for memory type index 10. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "           ATTRIBUTE11      ,   This field specifies the memory attributes for memory type index 11. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                     "
        bitfld.long 0x00 16.--19. "ATTRIBUTE12              ,   This field specifies the memory attributes for memory type index 12. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "       ATTRIBUTE13            ,   This field specifies the memory attributes for memory type index 13. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "         ATTRIBUTE14          ,   This field specifies the memory attributes for memory type index 14. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 28.--31. "           ATTRIBUTE15      ,   This field specifies the memory attributes for memory type index 15. " "NORMAL,FAULT,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xC05025D0++0x03
    line.long 0x00 "ST1MMUAS7_LOCKADDR_LO,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long.byte 0x00 6.--11. 1. " Res190                   ,Res190"
        hexmask.long.byte 0x00 0.--5. 1. "           LOCKADDR_SIZE          ,   This field contains the log  2 of the size of the region to lock, minus 1. Only values in the range 11 to 63 are valid values for this field, corresponding to region sizes of 4KB up to the entire address space. Values in the range 0 to 10 result in UNDEFINED behavior and should not be used."
        hexmask.long.tbyte 0x00 12.--31. 1. "             ST1MMUAS7LOCKADDR_LO ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC05025D4++0x03
    line.long 0x00 "ST1MMUAS7_LOCKADDR_HI,   This register tells the MMU to lock a region of virtual memory. All page mappings within this region must be flushed, and no translation requests within this region can complete or fault before the area is unlocked.  Only one region can be locked at a time.  As only 32 bits of the register can be written to at a time, no changes are issued until the LOCK command is written to the COMMAND register. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS7LOCKADDR_HI     ,   This field contains the lowest address in the region to be locked. The address is a virtual address in this address space.  Only the upper bits of the address are used. The address is aligned to a multiple of the region size, so a variable number of low-order bits are ignored, depending on the selected region size. It is recommended that software ensures that these low bits in the address are cleared, to avoid confusion. "

group d:0xC05025D8++0x03
    line.long 0x00 "ST1MMUAS7_COMMAND,   MMU commands are issued by writing to this register. Any command written to an address space while the corresponding STATUS.AS_ACTIVE flag is set will be ignored.  In general an MMU command only applies to the address space it is submitted to. However a command that invalidates the MMU cache may invalidate the whole MMU cache rather than only those entries specific to one address space. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS7COMMAND         ,ST1MMUAS7COMMAND"

group d:0xC05025DC++0x03
    line.long 0x00 "ST1MMUAS7_FAULTSTATUS,   This register contains extended status information after a fault. If read before a fault occurs, its contents are the reset value, 0, which indicates no fault.       If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  If the GPU is in protected mode, this register is not updated, and MMU faults are ignored.        They are not fatal but will halt the GPU until the MMU address space is updated.        However, no fault information wil be visible in this case.  Changed access type of MMU_FAULTSTATUS register when in protected mode. "
        hexmask.long.byte 0x00 10.--15. 1. " Res191                   ,Res191"
        hexmask.long.word 0x00 16.--31. 1. "           SOURCE_ID              ,   This field contains an implementation-defined ID that supplies additional data about the source of the fault. For example, it may be the ID of the internal bus master that issued the request that faulted. This makes it possible to distinguish between the job manager, the texture unit and the load/store unit. Another example might be an indication of the type of an invalid data structure. The values in this field are implementation defined. "
        hexmask.long.byte 0x00 0.--7. 1. "           EXCEPTION_TYPE       ,   This field indicates the type of exception that caused the fault. "
        bitfld.long 0x00 8.--9. "               ACCESS_TYPE      ,   This field contains the direction of data transfer that caused the fault, if known.  For the purposes of error reporting, atomic transactions act like a read followed by a write, so denying either permission will result in the atomic transaction failing, and the exceptions ACCESS_TYPE field will be set to 'atomic'. " "atomic,execute:  An execute transaction. ,read:  A read transaction. ,write:  A write transaction. "

group d:0xC05025E0++0x03
    line.long 0x00 "ST1MMUAS7_FAULTADDRESS_LO,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS7FAULTADDRESS_LO ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC05025E4++0x03
    line.long 0x00 "ST1MMUAS7_FAULTADDRESS_HI,   This register contains information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS7FAULTADDRESS_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the FAULTSTATUS register.  If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one. "

group d:0xC05025E8++0x03
    line.long 0x00 "ST1MMUAS7_STATUS,   This register contains dynamic status information about this address space. "
        hexmask.long 0x00 1.--31. 1. " Res192                   ,Res192"
        bitfld.long 0x00 0. "     AS_ACTIVE              ,   This flag is set while a MMU_UPDATE, LOCK, UNLOCK, FLUSH_PT or FLUSH_MEM command is active on this address space. This allows software to safely verify that the address space is in a consistent state after reconfiguring the MMU page tables.  If a new command is written to the corresponding COMMAND register while the AS_ACTIVE bit is set, then the command is ignored. " "false,true"

group d:0xC05025F0++0x03
    line.long 0x00 "ST1MMUAS7_TRANSCFG_LO,ST1MMUAS7_TRANSCFG_LO"
        bitfld.long 0x00 4.--5. " Res193                   ,Res193" "0,1,2,3"
        bitfld.long 0x00 11.--13. "            Res194                 ,Res194" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 19.--21. "              Res195               ,Res195" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 23. "                Res196           ,Res196" "0,1"
        textline "                                     "
        bitfld.long 0x00 26.--27. "Res197                   ,Res197" "0,1,2,3"
        bitfld.long 0x00 31. "            Res198                 ,Res198" "0,1"
        bitfld.long 0x00 6.--10. "              INA_BITS             ,   This field allows the system software to restrict the range of input addresses accepted by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  INA_BITS_VALID = min(HW_INA_BITS, 55-INA_BITS)  If the input address is outside the range (0, 2  INA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 14.--18. "               OUTA_BITS        ,   This field allows the system software to restrict the range of output addresses generated by this translation stage. This is used in conjunction with the hardware limits to determine the valid address range as follows:  OUTA_BITS_VALID = min(HW_OUTA_BITS, 55-OUTA_BITS)  If the translated output address is outside the range (0, 2  OUTA_BITS_VALID -1), then a TRANSLATION_FAULT error is generated." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        textline "                                     "
        bitfld.long 0x00 0.--3. "MODE                     ,   This field controls the overall operation of the MMU. There are some differences between stage 1 and stage 2.  Execute permissions for a page are evaluated as follows (PTE.&lt;W|R|X> refers to page table entry permissions resolved for hierarchical permissions (if applicable):  EXECUTE_ALLOWED = !((TRANSCFG.WXN &amp; !PTE.W) | (TRANSCFG.XREADABLE &amp; !PTE.R) | (!TRANSCFG.XREADABLE &amp; !PTE.X)) " "LEGACY,UNMAPPED,IDENTITY,3,4,5,AARCH64_4K,7,AARCH64_64K,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--25. "  PTW_MEMATTR            ,   Memory attributes for page table walks. The allowed values are compatible with the values allowed for  MEMORY_TYPE . For outer cache transactions, the desired attributes for the transaction will be decided by the bus master and communicated to the memory system using signals on the bus.  Changed allowed values for TRANSCFG.PTW_MEMATTR. " "0,NON_CACHEABLE,WRITE_BACK,3"
        bitfld.long 0x00 28.--29. "  PTW_SH               ,   This field specifies the shareability for the page table walks. This is the same encoding as used for ARMv8 page tables. " "non_shareable,1,outer_shareable,inner_shareable"
        bitfld.long 0x00 30. "  R_ALLOCATE       ,   This field sets the inner read allocation hint for the page table walks. This is the same encoding as used for ARMv8 page tables. " "no_read_allocate,read_allocate"
        textline "                                     "
        bitfld.long 0x00 22. "SL_CONCAT_EN             ,   If set then the page table walk starting level will be increased if possible by concatenating up to 16 tables in the starting level. " "false,true"

group d:0xC05025F4++0x03
    line.long 0x00 "ST1MMUAS7_TRANSCFG_HI,ST1MMUAS7_TRANSCFG_HI"
        bitfld.long 0x00 0. " Res199                   ,Res199" "0,1"
        hexmask.long 0x00 5.--31. 1. "            Res200                 ,Res200"
        bitfld.long 0x00 1. "       DISABLE_HIER_AP      ,   This flag only has an effect on stage 1 of translation. It is ignored for stage 2. Note the inverted logic - the flag must be set to  dis able hierarchical access permissions." "false,true"
        bitfld.long 0x00 2. "            DISABLE_AF_FAULT ,   This flag can be used to disable access fault checking when in one of AARCH64 modes. " "false,true"
        textline "                                     "
        bitfld.long 0x00 3. "WXN                      ,   This flag can be used to disable all writes to executable pages, overriding access permissions specified in the page table. " "false,true"
        bitfld.long 0x00 4. "        XREADABLE              ,   This flag can be used to enable execution on all readable pages, overriding access permissions specified in the page table. " "false,true"

group d:0xC05025F8++0x03
    line.long 0x00 "ST1MMUAS7_FAULTEXTRA_LO,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long 0x00 0.--31. 1. " ST1MMUAS7FAULTEXTRA_LO   ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "

group d:0xC05025FC++0x03
    line.long 0x00 "ST1MMUAS7_FAULTEXTRA_HI,   This register contains additional information about the cause of a page fault or bus error. "
        hexmask.long.word 0x00 16.--30. 1. " Res201                   ,Res201"
        hexmask.long.word 0x00 0.--15. 1. "         ST1MMUAS7FAULTEXTRA_HI ,   This field contains the virtual address (in this address space) of the access that caused the fault.  Additional information about the fault is also available in the  FAULTSTATUS and FAULTADDRESS registers. If multiple faults occur before the first is handled, the subsequent faults are ignored. They may fault again after handling the first one.  Fixed duplicate state name in FAULT_ADDRESS - exposes previously hidden field S2FS1WALK. "
        bitfld.long 0x00 31. "           S2FS1WALK            ,S2FS1WALK" "stage2,stage1"

tree.end

tree "pmuap"

width 28.

group d:0xD4282800++0x03
    line.long 0x00 "PMU_CC_CP,CP Clock Control Register"
        bitfld.long 0x00 31. " CP_RD_ST_CLEAR                  ,rd_st clear  cp_rd_status can be cleared by writing logic high on this bit." "0,1"
        bitfld.long 0x00 30. "         ACLK_DYN_FC15                    ,dynamic aclk clock change  writing this bit will change the bus clock without going through the core idle, memory controller idle process" "0,1"
        bitfld.long 0x00 29. "   DCLK_DYN_FC16                        ,dynamic dclk clock change  writing this bit will change the bus clock without going through the core idle, memory controller idle process" "0,1"
        bitfld.long 0x00 28. "   CORE_DYN_FC                      ,dynamic core clock change  writing this bit will change the core clock without going through the core idle, memory controller idle process" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "CP_ALLOW_SPD_CHG                ,<var processor: comm> speed change voting  1 = <var processor: comm> allows frequency change" "0,1"
        bitfld.long 0x00 26. "         BUS_FREQ_CHG_REQ19               ,aclk frequency change request. write 1 to vote frequency change." "0,1"
        bitfld.long 0x00 25. "   DDR_FREQ_CHG_REQ20                   ,dclk frequency change request. write 1 to vote frequency change" "0,1"
        bitfld.long 0x00 24. "   CP_FREQ_CHG_REQ                  ,<var processor: comm> frequency change request. write 1 to vote frequency change." "0,1"
        textline "                                      "
        bitfld.long 0x00 23. "ASYNC522                        ,ap bus interface sync with bus clock  1 = async must set to async" "0,1"
        bitfld.long 0x00 22. "         ASYNC423                         ,cp bus interface sync with bus interface  1 = async  this field must be set to async." "0,1"
        bitfld.long 0x00 21. "   ASYNC3_124                           ,axi bus interface sync with ddr controller  1 = async  this field must be set to async." "0,1"
        bitfld.long 0x00 20. "   ASYNC325                         ,axi bus interface sync with ddr clock  1 = async  this field must be set to async." "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "ASYNC226                        ,ap bus interface sync with ddr clock  1 = async  this field must be set to async." "0,1"
        bitfld.long 0x00 18. "         ASYNC127                         ,cp bus interface sync with ddr clock  1 = async  this field must be set to async." "0,1"
        bitfld.long 0x00 15.--17. "   BUS_CLK_DIV28                        ,clock divider selection for aclk, aclk = <aclk_selection> in fccr/ (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 12.--14. "   DDR_CLK_DIV29                    ,pll1 clock divider configuration for dclk  when fcdclk dclksel is not 3'b00x, dclk source is pll2, pll3, pll4 or pll1_1248 and the divider is bypassed. when dclksel is 3'b00x, pll1_832 or pll1_624 is selected. dclk = <dclk_selection> in fcdclk/ (this fie" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 0.--2. "CORE_CLK_DIV31                  ,clock divider selection for pclk of <var processor: comm>, pclk = (<var processor: comm> core clock selection in fccr) / (this field +1)" "0,1,2,3,4,5,6,7"

group d:0xD4282804++0x03
    line.long 0x00 "PMU_CC_AP,AP Clock Control Register"
        bitfld.long 0x00 31. " AP_RD_ST_CLEAR                  ,rd_st clear  ap_rd_status can be cleared by writing logic high on this bit" "0,1"
        bitfld.long 0x00 29. "         AP_C2_DYN_FC                     ,ap cluster2 dynamic clock change  writing this bit will change the core clock without going through the core idle, memory controller idle process" "0,1"
        bitfld.long 0x00 28. "   AP_C2_FREQ_CHG_REQ                   ,ap cluster2 frequency change request, the c2_clk_div and c2_aclk div is in pmu_cc3_ap register, should configure it before enable this bit" "0,1"
        bitfld.long 0x00 27. "   ACLK_DYN_FC42                    ,dynamic aclk clock change  writing this bit will change the bus clock without going through the core idle, memory controller idle process" "0,1"
        textline "                                      "
        bitfld.long 0x00 26. "DCLK_DYN_FC43                   ,dynamic dclk clock change  writing this bit will change the bus clock without going through the core idle, memory controller idle process" "0,1"
        bitfld.long 0x00 25. "         AP_C1_DYN_FC                     ,ap cluster1 dynamic clock change  writing this bit will change the core clock without going through the core idle, memory controller idle process" "0,1"
        bitfld.long 0x00 24. "   AP_C0_DYN_FC                         ,ap cluster0 dynamic clock change  writing this bit will change the core clock without going through the core idle, memory controller idle process" "0,1"
        bitfld.long 0x00 23. "   BUS_FREQ_CHG_REQ46               ,aclk frequency change request" "0,1"
        textline "                                      "
        bitfld.long 0x00 22. "DDR_FREQ_CHG_REQ47              ,dclk frequency change request" "0,1"
        bitfld.long 0x00 21. "         AP_C1_FREQ_CHG_REQ               ,ap cluster1 frequency change request" "0,1"
        bitfld.long 0x00 20. "   AP_C0_FREQ_CHG_REQ                   ,ap cluster0 frequency change request" "0,1"
        bitfld.long 0x00 18. "   AP_ALLOW_SPD_CHG                 ,ap speed change voting" "0,1"
        textline "                                      "
        bitfld.long 0x00 15.--17. "BUS_CLK_DIV52                   ,clock divider selection for aclk, aclk = <aclk_selection> in fcaclk/ (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 12.--14. "         DDR_CLK_DIV53                    ,pll1 clock divider configuration for dclk  when fcdclk dclksel is not 3'b00x, dclk source is pll2, pll3, pll4 or pll1_1248 and the divider is bypassed. when dclksel is 3'b00x, pll1_832 or pll1_624 is selected. dclk = <dclk_selection> in fcdclk/ (this field +1)." "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 9.--11. "   C1_ACLK_DIV54                        ,clock divider selection for cluster1 axi interface clock  c1_aclk is divided from pclk. c1_aclk= pclk / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 6.--8. "   C1_CLK_DIV55                     ,clock divider selection for cluster1 pclk. if (fcap.c1_pllsel<=3), pclk= (fcap.c1_pllsel selectin clock )/(c1_clk_div +1);  else pclk =fcap.c1_pllsel selectin clock" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 3.--5. "C0_ACLK_DIV56                   ,clock divider selection for cluster0 axi interface clock  c0_aclk is divided from pclk. c0_aclk= pclk / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0.--2. "         C0_CLK_DIV57                     ,clock divider selection for cluster0 pclk. if (fcap.c0_pllsel<=3), pclk= (fcap.c0_pllsel selectin clock )/(c0_clk_div +1);  else pclk =fcap.c0_pllsel selectin clock" "0,1,2,3,4,5,6,7"

group d:0xD4282808++0x03
    line.long 0x00 "PMU_DM_CC_CP,Dummy CP Clock Control Register"
        bitfld.long 0x00 31. " PM_AP_C2_FC_DONE64              ,ap frequency change done status  0x0 = frequency change is not done  0x1 = frequency change is done" "0,1"
        bitfld.long 0x00 30. "         PM_AP_C1_FC_DONE65               ,ap frequency change done status  0x0 = frequency change is not done  0x1 = frequency change is done" "0,1"
        bitfld.long 0x00 29. "   PM_ACLK_FC_DONE66                    ,aclk frequency change done status. this bit is set when a frequency change is done while the corresponding fc_req is still in assertion." "0,1"
        bitfld.long 0x00 28. "   PM_DCLK_FC_DONE67                ,dclk frequency change done status. this bit is set when a frequency change is done while the corresponding fc_req is still in assertion." "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "PM_AP_C0_FC_DONE68              ,ap frequency change done status. this bit is set when a frequency change is done while the corresponding fc_req is still in assertion." "0,1"
        bitfld.long 0x00 26. "         CP_FC_DONE69                     ,cp frequency change done status. this bit is set when a frequency change is done while the corresponding fc_req is still in assertion." "0,1"
        bitfld.long 0x00 25. "   AP_RD_STATUS70                       ,ap read status  indicates that the dummy ap clock register is being read by cp or ap.  reading the status is the beginning of the frequency update process. if this bit is set, it indicates that one of the cores is in the frequency update process and the other core must wait until the other core clears this bit (using the <rd_st clear> field in the ap clock control register) to indicate that the frequency change process has completed." "0,1"
        bitfld.long 0x00 24. "   CP_RD_STATUS71                   ,cp read status  indicates that the dummy cp clock register is being read by cp or ap.  reading the status is the beginning of the frequency update process. if this bit is set, it indicates that one of the cores is in the frequency update process and the other core must wait until the other core clears this bit (using the <rd_st clear> field in the cp clock control register) to indicate that the frequency change process has completed." "0,1"
        textline "                                      "
        bitfld.long 0x00 23. "ASYNC572                        ,ap bus interface sync with bus clock  1 = async" "0,1"
        bitfld.long 0x00 22. "         ASYNC473                         ,cp bus interface sync with bus clock  1 = async" "0,1"
        bitfld.long 0x00 21. "   ASYNC3_174                           ,axi bus interface sync with ddr clock  1 = async" "0,1"
        bitfld.long 0x00 20. "   ASYNC375                         ,axi bus interface sync with ddr controller  1 = async" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "ASYNC276                        ,ap bus interface sync with ddr controller  1 = async" "0,1"
        bitfld.long 0x00 18. "         ASYNC177                         ,cp bus interface sync with ddr controller  1 = async" "0,1"
        bitfld.long 0x00 15.--17. "   BUS_CLK_DIV78                        ,clock divider selection for aclk  aclk = <aclk_selection> in fccr/ (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 12.--14. "   DDR_CLK_DIV79                    ,clock divider selection for dclk  dclk = <dclk_selection> in fccr/ (this field +1)" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 0.--2. "CORE_CLK_DIV81                  ,clock divider selection for pclk of <var processor: comm>  pclk = (seagull core clock selection in fccr) / (this field +1)" "0,1,2,3,4,5,6,7"

group d:0xD428280C++0x03
    line.long 0x00 "PMU_DM_CC_AP,Dummy AP Clock Control Register"
        bitfld.long 0x00 31. " PM_AP_C2_FC_DONE88              ,ap frequency change done status  0x0 = frequency change is not done  0x1 = frequency change is done" "0,1"
        bitfld.long 0x00 30. "         PM_AP_C1_FC_DONE89               ,ap frequency change done status  0x0 = frequency change is not done  0x1 = frequency change is done" "0,1"
        bitfld.long 0x00 29. "   PM_ACLK_FC_DONE90                    ,aclk frequency change done status  0x0 = frequency change is not done  0x1 = frequency change is done" "0,1"
        bitfld.long 0x00 28. "   PM_DCLK_FC_DONE91                ,dclk frequency change done status  0x0 = frequency change is not done  0x1 = frequency change is done" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "PM_AP_C0_FC_DONE92              ,ap frequency change done status  0x0 = frequency change is not done  0x1 = frequency change is done" "0,1"
        bitfld.long 0x00 26. "         CP_FC_DONE93                     ,cp frequency change done status  0x0 = frequency change is not done  0x1 = frequency change is done" "0,1"
        bitfld.long 0x00 25. "   AP_RD_STATUS94                       ,ap read status  indicates that the dummy ap clock register is being read by cp or ap.  reading the status is the beginning of the frequency update process. if this bit is set, it indicates that one of the cores is in the frequency update process and the other core must wait until the other core clears this bit (using the <rd_st clear> field in the ap clock control register) to indicate that the frequency change process has completed." "0,1"
        bitfld.long 0x00 24. "   CP_RD_STATUS95                   ,cp read status  indicates that the dummy cp clock register is being read by cp or ap.  reading the status is the beginning of the frequency update process. if this bit is set, it indicates that one of the cores is in the frequency update process and the other core must wait until the other core clears this bit (using the <rd_st clear> field in the cp clock control register) to indicate that the frequency change process has completed." "0,1"
        textline "                                      "
        bitfld.long 0x00 23. "ASYNC596                        ,ap bus interface sync with bus interface" "0,1"
        bitfld.long 0x00 22. "         ASYNC497                         ,cp bus interface sync with bus interface" "0,1"
        bitfld.long 0x00 21. "   ASYNC3_198                           ,axi bus interface sync with ddr controller" "0,1"
        bitfld.long 0x00 20. "   ASYNC399                         ,axi bus interface sync with ddr controller" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "ASYNC2100                       ,ap bus interface sync with ddr controller" "0,1"
        bitfld.long 0x00 18. "         ASYNC1101                        ,cp bus interface sync with ddr controller" "0,1"
        bitfld.long 0x00 15.--17. "   BUS_CLK_DIV102                       ,clock divider selection for aclk, aclk = <aclk_selection> in fccr/ (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 12.--14. "   DDR_CLK_DIV103                   ,clock divider selection for dclk, dclk = <dclk_selection> in fccr/ (this field +1)" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 9.--11. "C1_ACLK_DIV104                  ,clock divider selection for cluster1 axi interface clock  c1_aclk is divided from pclk. c1_aclk= pclk / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 6.--8. "         C1_CLK_DIV105                    ,clock divider selection for cluster1 pclk. if (fcap.c1_pllsel<=3), pclk= (fcap.c1_pllsel selectin clock )/(c1_clk_div +1);  else pclk =fcap.c1_pllsel selectin clock" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3.--5. "   C0_ACLK_DIV106                       ,clock divider selection for cluster0 axi interface clock  c0_aclk is divided from pclk. c0_aclk= pclk / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0.--2. "   C0_CLK_DIV107                    ,clock divider selection for cluster0 pclk. if (fcap.c0_pllsel<=3), pclk= (fcap.c0_pllsel selectin clock )/(c0_clk_div +1);  else pclk =fcap.c0_pllsel selectin clock" "0,1,2,3,4,5,6,7"

group d:0xD4282810++0x03
    line.long 0x00 "PMU_FC_TIMER,Frequency Change Timer Register"
        hexmask.long 0x00 3.--31. 1. " TIMER                           ,frequency change timer  this field defines the frequency change timer value in 26 mhz clock unit"
        bitfld.long 0x00 1.--2. "  TIMER_SEL                        ,timer select  this field defines the timer for applying the clock changes for cp and ap.  0x0 = ap pmu internak timer  0x1 = gsm tcu signal  0x2 = wb rtu signal" "0,1,2,3"
        bitfld.long 0x00 0. "   TIMER_EN                             ,timer enable  this field defines the timer for frequency change sequence.  0 = timer expiration will not be required before applying the new clock divider settings  1 = timer expiration will be required before starting the clock divider settings" "0,1"

group d:0xD4282814++0x03
    line.long 0x00 "PMU_CP_IDLE_CFG,CP Idle Configuration Register"
        bitfld.long 0x00 27.--31. " SEA_SRAM_WAIT                   ,sram power up wait cycle  sram power up counter for 20 ns  this field should remain set to the default value and should not be changed." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 23.--26. "        SEA_SRAM_VMCVSSM                 ,l1/l2 pd vmc and vssm  this field lis the l1/l2 sram's pdlvmc and pdfvssm input. it should remain set to 0." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 21. "  SEA_DIS_MC_SW_REQ                    ,disable memory controller sw req  this field is used to disable the memory controller entry to idle mode using the memory controller sleep request bits. memory controller will always enter into idle mode based on the hardware state machine request.  0 =" "0,1"
        bitfld.long 0x00 20. "   PM_SEA_MC_WAKE_EN127             ,wake enable  wake up the memory controller when <var processor: comm> wakes up from core idle mode. memory controller will be woken up before the interrupt to the core is released.  0 = memory controller wake disabled  1 = memory controller wake up" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "CP_L2_PWR_SW                    ,l2sr swh  this field is the number of power switches for the l2 power.  0 = 1 power switch  1 = 2 power switches" "0,1"
        bitfld.long 0x00 18. "         CP_L1_PWR_SW                     ,l1sr swh  this field is the number of power switches for the l1 power.  0 = 1 power switch  1 = 2 power switches" "0,1"
        bitfld.long 0x00 16.--17. "   CP_CORE_PWR_SW                       ,swh  this field is the number of power switches for the core power  0x0 = 1 power switch  0x1 = 2 power switches  0x2 = 3 power switches  0x3 = 4 power switches" "0,1,2,3"
        bitfld.long 0x00 15. "   CP_DIS_L2_SLP2                   ,disable l2 slp2  this field is used to disable the cp l1/l2 power switch sleep2 power down during core power down mode.  1 = disable cp l2 power switch sleep2" "0,1"
        textline "                                      "
        bitfld.long 0x00 14. "CP_DIS_L2_SLP1                  ,disable l2 slp1  this field is used to disable the cp l1/l2 power switch sleep1 power down during core power down mode.  1 = disable cp l2 power switch sleep1" "0,1"
        bitfld.long 0x00 13. "         CP_DIS_SLP2                      ,disable slp2  this field is used to disable the cp core power switch sleep2 power down during core power down mode.  1 = disable ap power switch sleep2" "0,1"
        bitfld.long 0x00 12. "   CP_DIS_SLP1                          ,disable slp1  this field is used to disable the <var processor: application> core power switch sleep1 power down during core power down mode.  1 = disable ap power switch sleep1" "0,1"
        bitfld.long 0x00 11. "   SEA_MASK_JTAG_IDLE               ,mask the jtag idle check during core idle entry for <var processor: comm>  1 = mask the jtag idle check for <var processor: comm>" "0,1"
        textline "                                      "
        bitfld.long 0x00 10. "SEA_L2_CLK_DIS                  ,<var processor: comm> l2 clock enable/disable  1 = l2 controller clock is disabled  0 = l2 controller clock is enabled" "0,1"
        bitfld.long 0x00 9. "         SEA_L2_RESETN                    ,<var processor: comm> l2 assert reset  0 = l2 controller will be in reset  legacy bits only" "0,1"
        bitfld.long 0x00 8. "   CP_L2_ISOB                           ,cp l2 controller isolation enable  0 = isolation enable (power down mode)  1 = isolation disable (normal mode)  legacy bits only" "0,1"
        bitfld.long 0x00 7. "   CP_L2_PWR_OFF                    ,frc l2 sram off  1 = l2 cache power will be off, but l1 cache is retained" "0,1"
        textline "                                      "
        bitfld.long 0x00 6. "CP_SRAM_PWRDWN                  ,cp l1+l2 cache sram power down  1 = when the core issues idle (wait for interrupt or wfi command), the core will go into deep sleep mode and sram power will be off. cpu core will auto clear l1 cache." "0,1"
        bitfld.long 0x00 5. "         CP_PWRDWN                        ,cp power down  1 = when core issue idle (wait for interrupt or wfi command), the core will go into deep sleep mode." "0,1"
        bitfld.long 0x00 2. "   CP_DTCM_PDWN_DIS                     ,dtcm sram pdwn control disable  this field should be set to 0x0 so that tcm memory pdwn will be asserted automatically" "0,1"
        bitfld.long 0x00 0. "   MASK_WFI_CHECK145                ,debug only - it should be 0 during normal operation wfi state check mask  1 = status check masked  0 = status check not masked" "0,1"

group d:0xD428281C++0x03
    line.long 0x00 "PMU_SQU_CLK_GATE_CTRL,SQU Dynamic Clock Gate Control Register"
        bitfld.long 0x00 30. " MP3_MODE_EN                     ,1 = enable mp3 sleep mode.  0 = disable mp3 sleep mode" "0,1"
        bitfld.long 0x00 29. "         SQU_REFCLK_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 28. "   SQU_REFCLK_SW_EN                     ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 21. "   SQU_BANK4CLK_GATE_DIS            ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 20. "SQU_BANK4CLK_SW_EN              ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 19. "         SQU_BANK3CLK_GATE_DIS            ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 18. "   SQU_BANK3CLK_SW_EN                   ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 17. "   SQU_BANK2CLK_GATE_DIS            ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 16. "SQU_BANK2CLK_SW_EN              ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 15. "         SQU_BANK1CLK_GATE_DIS            ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 14. "   SQU_BANK1CLK_SW_EN                   ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 13. "   SQU_BANK0CLK_GATE_DIS            ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "SQU_BANK0CLK_SW_EN              ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 11. "         SQU_S8CLK_GATE_DIS               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 10. "   SQU_S8CLK_SW_EN                      ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 9. "   SQU_S4CLK_GATE_DIS               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "SQU_S4CLK_SW_EN                 ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 7. "         SQU_S1CLK_GATE_DIS               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 6. "   SQU_S1CLK_SW_EN                      ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 5. "   SQU_FMBISTCLK_GATE_DIS           ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "SQU_FMBISTCLK_SW_EN             ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 3. "         SQU_ROMCLK_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 2. "   SQU_ROMCLK_SW_EN                     ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 1. "   SQU_CLK_GATE_DIS                 ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "SQU_CLK_SW_EN                   ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"

group d:0xD4282820++0x03
    line.long 0x00 "PMU_JPG_CLK_RES_CTRL,JPG Clock/Reset Control Register"
        bitfld.long 0x00 17. " 2K_AFBC_CLK_EN                  ,2k afbc clock enable   1 = clock enabled  0 = clock disabled" "0,1"
        bitfld.long 0x00 16. "         4K_AFBC_CLK_EN                   ,4k afbc clock enable   1 = clock enabled  0 = clock disabled" "0,1"
        bitfld.long 0x00 15. "   JPG_CLK_FC_REQ                       ,jpg function clk fc request  1 = triggers a frequency change  this field is hardware cleared when the frequency change is done." "0,1"
        bitfld.long 0x00 5.--7. "   JPG_CLK_DIV                      ,jpg function clock divide ratio  isp_clk = jpg_clk_div / (this field +1)" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 2.--4. "JPG_CLK_SEL                     ,jpg function clock source select  0x0 = 624 mhz  0x1 = 499 mhz  0x2 = 832  0x3 = pll3_div3  0x4 = pll4_div2  0x5 = pll5_div2  0x6 = pll3_div2  0x7 = 1248mhz" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 1. "         JPG_CLK_EN                       ,jpg function clock enable  1 = clock enabled  0 = clock disabled" "0,1"
        bitfld.long 0x00 0. "   JPG_CLK_RSTN                         ,jpg function clock reset  0 = reset" "0,1"

group d:0xD4282824++0x03
    line.long 0x00 "PMU_CSI_CCIC2_CLK_RES_CTRL,CSI CCIC2 Clock/Reset Control Register"
        bitfld.long 0x00 31. " CCIC3_PHY_CLK_SEL               ,ccic3 phy clock select  0 = 104 mhz  1 = 52 mhz" "0,1"
        bitfld.long 0x00 30. "         CCIC3_PHY_CLK_EN                 ,ccic3 phy clock enable  1 = phy clock enabled  0 = phy clock disabled" "0,1"
        bitfld.long 0x00 29. "   CCIC3_PHY_CLK_RST                    ,ccic3 phy clock reset  this clock is also used for dphy reset.  0 = reset" "0,1"
        bitfld.long 0x00 28. "   CAM_MCLK0_EN                     ,cam mclk0 enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "CAM_MCLK_EN                     ,cam mclk enable" "0,1"
        bitfld.long 0x00 23.--26. "         ISIM_VCLK_OUT_DIV                ,clock divider for isim_vclk_out  the source sensor reference clock is selected by [9:8]. the divider of the sensor reference clock is controlled by this register.  isim_vclk_out = isim_vclk_out_div / (this field +1)  the default value is 312/(11+1) = 26 mhz" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--22. "  CSI_FNC_CLK_DIV                      ,csi controller function clock divide ratio  csi_fnc_clk = csi_fnc_clk_div / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 16.--18. "   CSI_CLK_SEL                      ,csi controller function clock source select  0x0 = pll3_div4 mhz  0x1 = pll4_div3  0x2 = 624   0x3 = pll3_div3   0x4 = 832 mhz  0x5 = pll4_div2  0x6 = pll3_div2   0x7 = pll2_div2" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 15. "CSI_CLK_FC_REQ                  ,csi controller function clk fc request  1 = trigger frequency change  this field is cleared when the fc completes." "0,1"
        bitfld.long 0x00 8.--9. "         CAM_MCLK_SEL                     ,cam mclkselect  0 = 312 mhz  1 = pll2_div5   2 = 416mhz   3 = pll4_div5" "0,1,2,3"
        bitfld.long 0x00 7. "   CCIC2_PHYCLK_SEL                     ,ccic2 phy clock select  0 = 104 mhz  1 = 52 mhz" "0,1"
        bitfld.long 0x00 6. "   CAM_MCLK1_EN                     ,cam mclk1 enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 5. "CCIC2_PHYCLK_EN                 ,ccic2 phy clock enable  1 = phy clock enabled  0 = phy clock disabled" "0,1"
        bitfld.long 0x00 4. "         CSI_CLK_EN                       ,csi controller function clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        bitfld.long 0x00 2. "   CCIC2_PHYCLK_RST                     ,ccic2 phy clock reset  this clock is also used for dphy reset.  0 = reset" "0,1"
        bitfld.long 0x00 1. "   CSI_CLK_RST                      ,reset for csi controller function clock  0 = reset" "0,1"

group d:0xD4282828++0x03
    line.long 0x00 "PMU_CCIC1_CLK_GATE_CTRL,CMOS Camera Interface Controller 1 Dynamic Clock Gate Control Register"
        bitfld.long 0x00 30.--31. " CCIC1_GATE_CSI_CLK_STATIC       ,ccic1 csi static clock gate control  0x0 = hardware dynamic control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 28.--29. "         CCIC1_GATE_CLK4X_STATIC          ,ccic1 clk1x static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 26.--27. "   CCIC1_GATE_CLK1X_STATIC              ,ccic1 hclk static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 24.--25. "   CCIC1_GATE_HCLK_STATIC           ,ccic1 aclk static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 22.--23. "CCIC1_GATE_ACLK_STATIC231       ,ccic1 aclk static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 20.--21. "         CCIC1_GATE_ISP_PIP1_CLK1X_STATIC ,isp pipe1 clk1x static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 18.--19. "   CCIC1_GATE_ACLK_STATIC233            ,ccic dma aclk static clock gate contro  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 16.--17. "   CCIC1_GATE_AXI_BRIDGE_CLK_STATIC ,ccic dma (axi bridge 64 to128) hclk static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 14.--15. "CCIC1_GATE_LANE3_CLK_DYNAMIC    ,ccic1 csi lane3 clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 12.--13. "         CCIC1_GATE_LANE2_CLK_DYNAMIC     ,ccic1 csi lane 2 clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 10.--11. "   CCIC1_GATE_LANE1_CLK_DYNAMIC         ,ccic1 csi lane 1 clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 8.--9. "   CCIC1_GATE_LANE0_CLK_DYNAMIC     ,ccic1 csi lane 0 clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 6.--7. "CCIC1_GATE_CSI_CLK_DYNAMIC      ,ccic1 csi clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 4.--5. "         CCIC1_GATE_AHB_CLK_DYNAMIC       ,ccic1 ahb clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 2.--3. "   CCIC1_GATE_PIP_CLK_DYNAMIC           ,ccic1 pipeline clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 0.--1. "   CCIC1_GATE__AXI_CLK_DYNAMIC      ,ccic1 axi clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"

group d:0xD428282C++0x03
    line.long 0x00 "PMU_FBRC0_CLK_GATE_CTRL,Fabric0 Dynamic Clock Gate Control Register"
        bitfld.long 0x00 28.--31. " PM_249                          ," "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 27. "        FBCR0_DTCCLK_SW_EN               ,axi fabric0 dtc port clock sw mode clock enable  1 = software control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 26. "   FBCR0_DTCCLK_GATE_DIS                ,axi fabric0 dtc port clock dynamic gating disable  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 25. "   FBCR0_S6CLK_SW_EN                ,axi fabric0 s6 port clock sw mode clock enable  1 = software control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 24. "FBCR0_S6CLK_GATE_DIS            ,axi fabric0 s6 port clock dynamic gating disable  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 23. "         FBCR0_S5CLK_SW_EN                ,axi fabric0 s5 port clock sw mode clock enable  1 = software control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 22. "   FBCR0_S5CLK_GATE_DIS                 ,axi fabric0 s5 port clock dynamic gating disable  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 21. "   FBCR0_S4CLK_SW_EN                ,axi fabric0 s4 port clock sw mode clock enable  1 = software control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 20. "FBCR0_S4CLK_GATE_DIS            ,axi fabric0 s4 port clock dynamic gating disable  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 19. "         FBCR0_S3CLK_SW_EN                ,axi fabric0 s3 port clock sw mode clock enable  1 = software control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 18. "   FBCR0_S3CLK_GATE_DIS                 ,axi fabric0 s3 port clock dynamic gating disable  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 17. "   FBCR0_S2CLK_SW_EN                ,axi fabric0 s2 port clock sw mode clock enable  1 = software control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 16. "FBCR0_S2CLK_GATE_DIS            ,axi fabric0 s2 port clock dynamic gating disable  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 15. "         FBCR0_S1CLK_SW_EN                ,axi fabric0 s1 port clock sw mode clock enable  1 = software control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 14. "   FBCR0_S1CLK_GATE_DIS                 ,  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 13. "   FBCR0_S0CLK_SW_EN                ,  1 = software control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "FBCR0_S0CLK_GATE_DIS            ,  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 11. "         FBCR0_M4CLK_SW_EN                ,  1 = software control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 10. "   FBCR0_M4CLK_GATE_DIS                 ,  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 9. "   FBCR0_M3CLK_SW_EN                ,  1 = software control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "FBCR0_M3CLK_GATE_DIS            ,  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 7. "         FBCR0_M2CLK_SW_EN                ,  1 = software control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 6. "   FBCR0_M2CLK_GATE_DIS                 ,  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 5. "   FBCR0_M1CLK_SW_EN                ,  1 = software control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "FBCR0_M1CLK_GATE_DIS            ,  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 3. "         FBCR0_M0CLK_SW_EN                ,  1 = software control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 2. "   FBCR0_M0CLK_GATE_DIS                 ,  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"
        bitfld.long 0x00 1. "   FBCR0_CLK_SW_EN                  ,  1 = software control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "FBCR0_CLK_GATE_DIS              ,  1 = clock enable in software mode  0 = clock disable in software mode" "0,1"

group d:0xD4282830++0x03
    line.long 0x00 "PMU_FBRC1_CLK_GATE_CTRL,Fabric1 Dynamic Clock Gate Control Register"
        hexmask.long.word 0x00 20.--31. 1. " PM_284                          ,"
        bitfld.long 0x00 19. "      FBCR1_S12CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 18. "   FBCR1_S12CLK_GATE_DIS                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 17. "   FBCR1_S11CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 16. "FBCR1_S11CLK_GATE_DIS           ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 15. "         FBCR1_S10CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 14. "   FBCR1_S10CLK_GATE_DIS                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 13. "   FBCR1_M15CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "FBCR1_M15CLK_GATE_DIS           ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 11. "         FBCR1_M14CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 10. "   FBCR1_M14CLK_GATE_DIS                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 9. "   FBCR1_M13CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "FBCR1_M13CLK_GATE_DIS           ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 7. "         FBCR1_M12CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 6. "   FBCR1_M12CLK_GATE_DIS                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 5. "   FBCR1_M11CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "FBCR1_M11CLK_GATE_DIS           ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 3. "         FBCR1_M10CLK_SW_EN               ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 2. "   FBCR1_M10CLK_GATE_DIS                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 1. "   FBCR1_CLK_SW_EN                  ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "FBCR1_CLK_GATE_DIS              ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"

group d:0xD4282834++0x03
    line.long 0x00 "PMU_USB_CLK_GATE_CTRL,USB Dynamic Clock Gate Control Register"
        hexmask.long.byte 0x00 24.--31. 1. " PM_311                          ,"
        bitfld.long 0x00 23. "        SPH_ACLK_GATE_DIS                ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 22. "   SPH_ACLK_SW_EN                       ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 21. "   SPH_RXCLKA_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 20. "SPH_RXCLKA_SW_EN                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 19. "         SPH_TXCLKB_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 18. "   SPH_TXCLKB_SW_EN                     ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 17. "   SPH_RXCLKB_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 16. "SPH_RXCLKB_SW_EN                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 15. "         SPH_TXCLKA_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 14. "   SPH_TXCLKA_SW_EN                     ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 13. "   SPH_CLK_GATE_DIS                 ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "SPH_CLK_SW_EN                   ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 11. "         USB_ACLK_GATE_DIS                ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 10. "   USB_ACLK_SW_EN                       ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 9. "   USB_RXCLKA_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "USB_RXCLKA_SW_EN                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 7. "         USB_TXCLKB_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 6. "   USB_TXCLKB_SW_EN                     ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 5. "   USB_RXCLKB_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "USB_RXCLKB_SW_EN                ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 3. "         USB_TXCLKA_GATE_DIS              ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        bitfld.long 0x00 2. "   USB_TXCLKA_SW_EN                     ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"
        bitfld.long 0x00 1. "   USB_CLK_GATE_DIS                 ,1 = sw control enable  0 = hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "USB_CLK_SW_EN                   ,1 = clock enable in sw mode  0 = clock disable in sw mode" "0,1"

group d:0xD4282838++0x03
    line.long 0x00 "PMU_ISP_CLK_RES_CTRL,ISP Clock/Reset Control Register"
        bitfld.long 0x00 31. " ISP_PDWN                        ,isp power down control  this field is active high." "0,1"
        bitfld.long 0x00 30. "         ISP_REPAIR_MEM_CTRL_TRIG         ,isp repairable memory control trigger  1 = triggers isp repairable memory control  this register is hardware cleared when the repair to memory control is done." "0,1"
        bitfld.long 0x00 29. "   ISP_REPAIR_MEM_CTRL_DONE_BYPASS      ,isp repairable memory control done bypass in isp hardware mode  this field is valid when the isp is in hardware mode (isp_hw_mode = 1)." "0,1"
        bitfld.long 0x00 28. "   ISP_MCU_CLK_EN                   ,isp mcu function clock enable  1 = clock enabled  0 = clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "ISP_MCU_CLK_RSTN                ,isp mcu clock reset  0 = reset" "0,1"
        bitfld.long 0x00 26. "         ISP_MCU_CLK_SEL                  ,isp mcu clock divider  0 = 312mhz  1 = 416mhz" "0,1"
        bitfld.long 0x00 24.--25. "   ISP_MCU_CLK_DIV                      ,isp mcu clock divider  isp_mcu_clk = clk/ (this field +1)" "0,1,2,3"
        bitfld.long 0x00 23. "   ISP_CI_BUS_CLK_FC_REQ            ,isp_ci bus clock fc request  1 = triggers a frequency change  this field is hardware cleared when the frequency change is done." "0,1"
        textline "                                      "
        bitfld.long 0x00 21.--22. "ISP_CI_BUS_CLK_SEL              ,isp_ci bus clock select  0x0 =pll1-624 mhz  0x1 = pll1-832 mhz  0x2 = pll1-499m  0x3 =  pll4_div3" "0,1,2,3"
        bitfld.long 0x00 18.--20. "         ISP_CI_BUS_CLK_DIV               ,isp_ci bus clock divide ratio  isp_ci_divided_bus_clk = isp_ci_bus_clk / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 17. "   ISP_CI_BUS_CLK_EN                    ,isp_ci bus clk enable  this field is the dma clk enable for ccic and isp. it controls the first level axi clock gating for ccic and isp. the second level axi clock gating for ccic and isp each have separate gating control registers.< p>1 = clock enabled<" "0,1"
        bitfld.long 0x00 16. "   ISP_CI_BUS_CLK_RST               ,isp_ci bus clk reset  0 = reset<p>this reset will reset all the axi logic in sc2 expect isp axi logic" "0,1"
        textline "                                      "
        bitfld.long 0x00 15. "ISP_HW_MODE                     ,isp hardware on/off control mode  1 = hardware controls isp on/off procedure" "0,1"
        bitfld.long 0x00 14. "         ISP_SLEEP2                       ,isp power switch sleep2" "0,1"
        bitfld.long 0x00 13. "   ISP_SLEEP1                           ,isp power switch sleep1" "0,1"
        bitfld.long 0x00 12. "   ISP_ISOB                         ,isp isolation cell enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 8.--10. "ISP_CLK_SEL                     ,isp function clock source select: [bit9, bit3, bit2]   0x0 = 416 mhz  0x1 = 499 mhz  0x2 = 624   0x3 = pll4_div4   0x4 = pll5_div3   0x5= pll5_div5  0x6 = pll2_div4   0x7 = pll3_div3" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 7. "         ISP_CLK_FC_REQ                   ,isp function clk fc request  1 = triggers a frequency change  this field is hardware cleared when the frequency change is done." "0,1"
        bitfld.long 0x00 4.--6. "   ISP_CLK_DIV                          ,isp function clock divide ratio  isp_clk = isp_clk_div / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   ISP_AXI_RESETN                   ,isp axi resetn  0 =  reset" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "ISP_CLK_EN                      ,isp function clock enable  1 = clock enabled  0 = clock disabled" "0,1"
        bitfld.long 0x00 0. "         ISP_CLK_RSTN                     ,isp function clock reset  0 = reset" "0,1"

group d:0xD4282840++0x03
    line.long 0x00 "PMU_PMU_CLK_GATE_CTRL,PMU Dynamic Clock Gate Control Register"
        bitfld.long 0x00 31. " 1248M_D1P_EN                    ,1 = clock enable  0 = clock disable. in d0, this bit is not used" "0,1"
        bitfld.long 0x00 30. "         832M_D1P_EN                      ,1 = clock enable  0 = clock disable. in d0, this bit is not used" "0,1"
        bitfld.long 0x00 29. "   624M_D1P_EN                          ,1 = clock enable  0 = clock disable. in d0, this bit is not used" "0,1"
        bitfld.long 0x00 28. "   499M_D1P_EN                      ,1 = clock enable  0 = clock disable. in d0, this bit is not used" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "416M_D1P_EN                     ,1 = clock enable  0 = clock disable. in d0, this bit is not used" "0,1"
        bitfld.long 0x00 26. "         312M_D1P_EN                      ,1 = clock enable  0 = clock disable. in d0, this bit is not used" "0,1"
        bitfld.long 0x00 25. "   ULPI_CLK_SW_EN                       ,1 = clock enable  0 = clock disable" "0,1"
        bitfld.long 0x00 24. "   AP_32K_CLK_SW_EN                 ,1 = clock enable  0 = clock disable" "0,1"
        textline "                                      "
        bitfld.long 0x00 21. "SYS_1M_CLK_SW_EN                ,1 = clock enable  0 = clock disable" "0,1"
        bitfld.long 0x00 20. "         SYS_62P4M_CLK_SW_EN              ,1 = clock enable  0 = clock disable. if <62p4m_clock_gen_input_312m_clk_sw_en> is 0, this bit is unuseful" "0,1"
        bitfld.long 0x00 19. "   62P4M_CLOCK_GEN_INPUT_312M_CLK_SW_EN ,1 = clock enable  0 = clock disable" "0,1"
        bitfld.long 0x00 18. "   AUDIO_13M_3P25M_INPUT_CLK_EN     ,1 = clock enable  0 = clock disable" "0,1"
        textline "                                      "
        bitfld.long 0x00 17. "ICU_ACLK_SW_EN                  ,1 = clock enable    0 = clock disable. this bit is only used when <icu_aclk_en_ctrl_mode>=1" "0,1"
        bitfld.long 0x00 16. "         ICU_ACLK_EN_CTRL_MODE            ,1 = clock enable controlled by sw register bit <icu_aclk_sw_en>    0 = clock enable controlled by hardware dynamic gating" "0,1"
        bitfld.long 0x00 15. "   AP_PMU_CLK_SW_EN                     ,1 = clock enable    0 = clock disable. this bit is only used when <ap_pmu_clk_en_ctrl_mode>=1" "0,1"
        bitfld.long 0x00 14. "   AP_PMU_CLK_EN_CTRL_MODE          ,1 = clock enable controlled by sw register bit <ap_pmu_clk_sw_en>    0 = clock enable controlled by hardware dynamic gating" "0,1"
        textline "                                      "
        bitfld.long 0x00 13. "MP_PMU_CLK_SW_EN                ,1 = clock enable    0 = clock disable. this bit is only used when <mp_pmu_clk_en_ctrl_mode>=1" "0,1"
        bitfld.long 0x00 12. "         MP_PMU_CLK_EN_CTRL_MODE          ,1 = clock enable controlled by sw register bit <mp_pmu_clk_sw_en>    0 = clock enable controlled by hardware dynamic gating" "0,1"
        bitfld.long 0x00 10.--11. "   PM_391                               ,reserved for future use" "0,1,2,3"
        bitfld.long 0x00 9. "   SYS_ACLK_SW_EN                   ,1 = clock enable    0 = clock disable. this bit is only used when <sys_aclk_en_ctrl_mode>=1" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "SYS_ACLK_EN_CTRL_MODE           ,1 = clock enable controlled by sw register bit <sys_aclk_sw_en>    0 = clock enable controlled by hardware dynamic gating" "0,1"
        hexmask.long.byte 0x00 2.--7. 1. "         PM_394                           ,reserved for future use"
        bitfld.long 0x00 1. "  FC_SM_REF_CLK_SW_EN                  ,1 = clock enable    0 = clock disable. this bit is only used when <fc_sm_ref_clk_en_ctl_mode>=1" "0,1"
        bitfld.long 0x00 0. "   FC_SM_REF_CLK_EN_CTL_MODE        ,1 = clock enable controlled by sw register bit <fc_sm_ref_clk_sw_en>    0 = clock enable controlled by hardware dynamic gating" "0,1"

group d:0xD4282844++0x03
    line.long 0x00 "PMU_LCD_CLK_RES_CTRL1,LCD Clock/Reset Control Register1"
        bitfld.long 0x00 31. " MIPI_BIT_CLK_FC_REQ             ,mipi bit clk fc request  write 1 to trigger a frequency change. this field is hardware cleared when the frequency change completes." "0,1"
        bitfld.long 0x00 30. "         LCD_PXCLK_FC_REQ                 ,lcd pxclk fc request  write 1 to trigger a frequency change. this field is hardware cleared when the frequency change completes." "0,1"
        bitfld.long 0x00 29. "   LCD_MCLK_FC_REQ                      ,lcd mclk fc request  write 1 to trigger a frequency change. this field is hardware cleared when the frequency change completes." "0,1"
        bitfld.long 0x00 28. "   LCD_ACLK_FC_REQ                  ,lcd aclk fc request  write 1 to trigger a frequency change. this field is hardware cleared when the frequency change completes." "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "PM_HW_MODE407                   ,hardware control mode for lcd power up and power down" "0,1"
        bitfld.long 0x00 26. "         LCD_SLEEP2                       ,lcd power switch sleep2" "0,1"
        bitfld.long 0x00 25. "   LCD_SLEEP1                           ,lcd power switch sleep1" "0,1"
        bitfld.long 0x00 24. "   LCD_ISOB                         ,lcd isolation wrapper  0 = enable isolation (lcd powr-down mode)  1 = disable isolation (lcd active mode)" "0,1"
        textline "                                      "
        bitfld.long 0x00 23. "MIPI_BIT_BLANK_MSK              ,mipi bit clk fc wait blank signal mask   0 wait lcd blank signal   1 not wait lcd blank signal" "0,1"
        bitfld.long 0x00 20.--22. "         MIPI_BIT_CLK_SEL                 ,mipi bit clk clock select   0x0 = 832mhz mhz  0x1 = 624mhz  0x2 = pll5_div2   0x3 = pll3_div2   0x4 =1248    0x5 = 499    0x6 = pll4_div2    0x7 = pll3_div3" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 17.--19. "   MIPI_BIT_CLK_DIV                     ,mipi bit clock divide ratio  mipi_bit_clk = clock source/ (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 16. "   MIPI_BIT_CLK_EN                  ,mipi bit clk enable   0x0 = disable   0x1 =enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 15. "MIPI_BIT_CLK_RST                ,mipi bit clk  reset    0x0 = reset    0x1 = no reset" "0,1"
        bitfld.long 0x00 14. "         LCD_ACLK_BLANK_MSK               ,lcd aclk fc wait blank signal mask   0 wait lcd blank signal   1 not wait lcd blank signal" "0,1"
        bitfld.long 0x00 12.--13. "   LCD_ACLK_SEL                         ,lcd axi clock select  0x0 = 416 mhz  0x1 = 499 mhz  0x2 = 624 clock  0x3 = pll5_div2" "0,1,2,3"
        bitfld.long 0x00 9.--11. "   LCD_ACLK_DIV                     ,lcd axi clock divide ratio  lcd_aclk = clock source  / (this field +1)" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 8. "LCD_ACLK_EN                     ,lcd axi enable   0x0 = disable   0x1 =enable" "0,1"
        bitfld.long 0x00 7. "         LCD_ACLK_QCHAN_MASK              ,lcd axi q-channel mask   0 = not mask, q-channel enable    1 mask, q-channel disabled" "0,1"
        bitfld.long 0x00 6. "   LCD_HCLK_SWAP_CTRL                   ,lcd hclk swap  this field is used to control the hclk source of lcd in d1p mode.  0x0 = system fabric clock for lcd hclk source in d1p mode  0x1 = bypass vctxo clock for lcdhclk source in d1p mode" "0,1"
        bitfld.long 0x00 5. "   LCD_HCLK_EN                      ,lcd  hclk enable   0x0 = disabled   0x1= enabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "LCD_SW_RST                      ,lcd software reset    0x0 = reset    0x1 = no reset" "0,1"
        bitfld.long 0x00 3. "         DSI_ESCCLK_RESET                 ,dsi esc clock reset  0 = reset" "0,1"
        bitfld.long 0x00 2. "   DSI_ESC_EN                           ,dsi esc clock enable  1 = ref clock enabled  0 = ref clock disabled" "0,1"
        bitfld.long 0x00 0.--1. "   DSI_ESC_SEL                      ,dsi esc clock select  0x0 = 52 mhz  0x1 = 48 mhz  0x2 = 26 mhz  0x3 = 78 mhz" "0,1,2,3"

group d:0xD428284C++0x03
    line.long 0x00 "PMU_LCD_CLK_RES_CTRL2,LCD Clock/Reset Control Register2"
        bitfld.long 0x00 23. " LCD_PXCLK_BLANK_MSK             ,lcd pxclk fc wait blank signal mask   0 wait lcd blank signal   1 not wait lcd blank signal" "0,1"
        bitfld.long 0x00 20.--22. "         LCD_PXCLK_SEL                    ,lcd pxclkclock select   0x0 = 624mhz mhz  0x1 = 499mhz  0x2 = pll5_div3   0x3 = pll3_div4   0x4 =pll4_div4    0x5 = pll1_416" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 17.--19. "   LCD_PXCLK_DIV                        ,lcd pxclk clock divide ratio   lcd_pxclk = clock source/ (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 16. "   LCD_PXCLK_EN                     ,lcd pxclk enable   0x0 = disable   0x1 =enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "LCD_MCLK_BLANK_MSK              ,lcd mclk fc wait blank signal mask   0 wait lcd blank signal   1 not wait lcd blank signal" "0,1"
        bitfld.long 0x00 4.--6. "         LCD_MCLK_SEL                     ,lcd mclkclock select   0x0 = 624mhz mhz  0x1 = 499mhz  0x2 = pll5_div3   0x3 = pll5_div4   0x4 =pll4_div4    0x5 = pll1_416   0x6= pll3_div4 <0x7> pll4_div3" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 1.--3. "   LCD_MCLK_DIV                         ,lcd mclk clock divide ratio   lcd_mclk = clock source/ (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0. "   LCD_MCLK_EN                      ,lcd mclk enable   0x0 = disable   0x1 =enable" "0,1"

group d:0xD4282850++0x03
    line.long 0x00 "PMU_CCIC_CLK_RES_CTRL,CCIC Clock/Reset Control Register"
        bitfld.long 0x00 31. " CCIC_ISP_HCLK_SWAP_CTRL         ,ccic isp hclk swap  this field is used to control the hclk source of ccic and isp in d1p mode.  0x0 = system fabric clock for ccic and isp hclk source in d1p mode  0x1 = bypass vctxo clock for ccic and isp hclk source in d1p mode" "0,1"
        bitfld.long 0x00 23.--25. "         CCICI_CLK4X_SEL                  ,cmos camera interface controller clock source select  0x0 = pll3_div4  0x1 = pll4_div3  0x2 = 624  0x3 = pll3_div3   0x4 = 832  0x5= pll4_div2  0x6 = pll3_div2  0x7 = 1248m" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 22. "   ISP_CCIC_AHB_RST                     ,ahb clock reset for ccic and isp  0 = reset" "0,1"
        bitfld.long 0x00 21. "   ISP_CCIC_AHBCLK_EN               ,ahb clock enable for ccic and isp  1 = clock enabled  0 = clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 18.--20. "CICIC_CLK4X_DIV                 ,ci function clock divide ratio  ci_fnc_clk = ci_fnc_clk_div / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 15. "         CCIC_CLK4X_FC_REQ                ,ccic function clk4x fc request  write 1 to trigger a frequency change. this field is hardware cleared when the frequency change completes." "0,1"
        bitfld.long 0x00 7. "   CCIC1_PHYCLK_SEL                     ,ccic1 phy clock select  0 = 104 mhz  1 = 52 mhz" "0,1"
        bitfld.long 0x00 5. "   CCIC1_PHYCLK_EN                  ,ccic1 phy clock enable  1 = phy clock enabled  0 = phy clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "CCIC_CLK4X_EN                   ,cmos camera interface controller peripheral clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        bitfld.long 0x00 2. "         CCIC1_PHYCLK_RST                 ,ccic1 phy clock reset  this clock is also used for dphy reset.  0 = reset" "0,1"
        bitfld.long 0x00 1. "   CCIC_CLK4X_RST                       ,cmos camera interface controller peripheral reset  0 = reset" "0,1"

group d:0xD4282854++0x03
    line.long 0x00 "PMU_SDH0_CLK_RES_CTRL,SDH0 Clock/Reset Control Register"
        bitfld.long 0x00 11. " SDH0_CLK_FC_REQ                 ,sdh0 clock frequency change request  when this field is written as 1, it will force sdh0_clk_div to work.  this field will be automatically cleared by hardware when clock switch is done." "0,1"
        bitfld.long 0x00 8.--10. "         SDH0_CLK_DIV                     ,sdh0 clock frequency divisor  0x0 to 0x7 =  sdh0_clk = sdh0 source clock/(sdh0_clk_div + 1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 6.--7. "   SDH0_CLK_SEL                         ,sdh0 clock source select   0=416mhz(clk_in_416m_pll1)   1=624mhz(clk_in_pll1_2x)   2=clk_in_pll6_div2   3=400mhz(clk_in_pll6_div4)" "0,1,2,3"
        bitfld.long 0x00 4. "   SDH0_CLK_EN                      ,sdh0 peripheral clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "SDH_AXICLK_EN                   ,all sdh axi clock enable  this field is used to enable the axi click for all 3 sdh modules.  1 = axi clock enabled  0 = axi clock disabled" "0,1"
        bitfld.long 0x00 1. "         SDH0_RST                         ,sdh0 peripheral reset  0 = reset" "0,1"
        bitfld.long 0x00 0. "   SDH_AXI_RST                          ,all sdh axi reset  this field is used to perform an axi reset for all 3 sdh modules." "0,1"

group d:0xD4282858++0x03
    line.long 0x00 "PMU_SDH1_CLK_RES_CTRL,SDH1 Clock/Reset Control Register"
        bitfld.long 0x00 11. " SDH1_CLK_FC_REQ                 ,sdh1 clock frequency change request  when this field is written as 1, it will force sdh1_clk_div to work.  this field will be automatically cleared by hardware when clock switch is done." "0,1"
        bitfld.long 0x00 8.--10. "         SDH1_CLK_DIV                     ,sdh1 clock frequency divisor  0-7 = sdh1_clk = sdh1 source clock/(sdh1_clk_div + 1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 6.--7. "   SDH1_CLK_SEL                         ,sdh1 clock source select   0=416mhz(clk_in_416m_pll1)   1=624mhz(clk_in_pll1_2x)   2=clk_in_pll6_div2   3=400mhz(clk_in_pll6_div4)" "0,1,2,3"
        bitfld.long 0x00 4. "   SDH1_CLK_EN                      ,sdh1 peripheral clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "SDH1_RST                        ,sdh1 peripheral reset  0 = reset" "0,1"

group d:0xD428285C++0x03
    line.long 0x00 "PMU_USB_CLK_RES_CTRL,USB Clock/Reset Control Register"
        bitfld.long 0x00 9.--10. " USB_SS_SCALEDOWN_MODE           ,usb simulation scaledown mode, when this signal is enabled during simulation, the core uses scaled-down timing values, resulting in faster simulations.  0 = disable all scale-downs   1 = enable scale-down of all timing values except device mode suspend and resume   2 = enable scale-down of device mode suspend and resume timing values only   3 = enable all above scale-down timing values." "0,1,2,3"
        bitfld.long 0x00 8. "         USB_BYPASS_DEB_FILTER            ,usb bypass debounce filters for avalid, bvalid, vbusvalid, sessend, iddig signal when enabled  1 =  enabled  0 = disabled" "0,1"
        bitfld.long 0x00 1. "   USB_AXICLK_EN                        ,usb axi clock enable  1 = axi clock enabled  0 = axi clock disabled" "0,1"
        bitfld.long 0x00 0. "   USB_AXI_RST                      ,usb axi reset  0 = reset   1 = de-reset" "0,1"

group d:0xD4282860++0x03
    line.long 0x00 "PMU_NF_CLK_RES_CTRL,NAND Flash Clock/Reset Control Register"
        bitfld.long 0x00 8. " NF_ECC_RES                      ,nand flash ecc reset  0 = reset" "0,1"
        bitfld.long 0x00 7. "         NF_ECC_CLK_EN                    ,nand flash ecc clock enable  1 = ecc clock enabled  0 = ecc clock disabled" "0,1"
        bitfld.long 0x00 6. "   NF_CLK_SEL                           ,nand flash clock select  0 = 156 mhz  1 = 78 mhz" "0,1"
        bitfld.long 0x00 4. "   NF_CLK_EN                        ,nand flash peripheral clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "NF_AXICLK_EN                    ,nand flash axi clock enable  1 = axi clock enabled  0 = axi clock disabled" "0,1"
        bitfld.long 0x00 1. "         NF_RST                           ,nand flash peripheral reset  0 = reset" "0,1"
        bitfld.long 0x00 0. "   NF_AXI_RST                           ,nand flash axi reset" "0,1"

group d:0xD4282864++0x03
    line.long 0x00 "PMU_DMA_CLK_RES_CTRL,DMA Clock/Reset Control Register"
        bitfld.long 0x00 3. " DMA_AXICLK_EN                   ,dma axi clock enable  1 = axi clock enabled  0 = axi clock disabled" "0,1"
        bitfld.long 0x00 0. "         DMA_AXI_RST                      ,dma axi reset" "0,1"

group d:0xD4282868++0x03
    line.long 0x00 "PMU_AES_CLK_RES_CTRL,AES Clock/Reset Control Register"
        bitfld.long 0x00 6. " WTM_CLK_SEL                     ,wtm clock select  1 = 104 mhz  0 = 208 mhz" "0,1"
        bitfld.long 0x00 5. "         WTM_CLK_EN                       ,wtm clock enable  1 = wtm clock enabled  0 = wtm clock disabled" "0,1"
        bitfld.long 0x00 4. "   WTM_RST                              ,wtm clock reset" "0,1"

group d:0xD428286C++0x03
    line.long 0x00 "PMU_MCB_CLK_RES_CTRL,MCB Clock/Reset Control Register"
        bitfld.long 0x00 1. " ACLK_SW_RST                     ,mcb aclk port reset  0 = reset" "0,1"
        bitfld.long 0x00 0. "         DCLK_SW_RST                      ,mcb dclk domain reset  0 = reset" "0,1"

group d:0xD4282870++0x03
    line.long 0x00 "PMU_CP_IMR,PMU CP Interrupt Mask Register"
        bitfld.long 0x00 25. " AP_C2_FC_INTR_MASK              ,frequency change done by ap cluster2 interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 22. "         AP_CORE9_IDLE_WAKE_INTR_MASK564  ,debug only: <var processor: application> core9 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 21. "   AP_CORE8_IDLE_WAKE_INTR_MASK565      ,debug only: <var processor: application> core8 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 20. "   AP_C1_FC_INTR_MASK               ,frequency change done by ap cluster1 interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "AP_CORE7_IDLE_WAKE_INTR_MASK567 ,debug only: <var processor: application> core7 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 18. "         AP_CORE6_IDLE_WAKE_INTR_MASK568  ,debug only: <var processor: application> core6 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 17. "   AP_CORE5_IDLE_WAKE_INTR_MASK569      ,debug only: <var processor: application> core5 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 16. "   AP_CORE4_IDLE_WAKE_INTR_MASK570  ,debug only: <var processor: application> core4 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "SP_CORE_IDLE_WAKE_INTR_MASK572  ,debug only: <var processor: <var processor: <var processor: <var processor: <var processor: secure>>>>> core idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 10. "         AP_CORE3_IDLE_WAKE_INTR_MASK573  ,debug only: <var processor: application> core3 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 9. "   AP_CORE2_IDLE_WAKE_INTR_MASK574      ,debug only: <var processor: application> core2 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 8. "   AP_CORE1_IDLE_WAKE_INTR_MASK575  ,debug only: <var processor: application> core1 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "AP_CORE0_IDLE_WAKE_INTR_MASK576 ,debug only: <var processor: application> core0 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 6. "         CP_IDLE_WAKE_INTR_MASK577        ,debug only: cp idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 5. "   ACLK_FC_DONE_INTR_MASK578            ,debug only: aclk frequency change done interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 4. "   DCLK_FC_DONE_INTR_MASK579        ,debug only: dclk frequency change done interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "AP_FC_DONE_INTR_MASK            ,debug only: frequency change done for ap interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 2. "         CP_FC_DONE_INTR_MASK581          ,debug only: frequency change done for cp interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 1. "   AP_C0_FC_INTR_MASK                   ,frequency change done by ap cluster0 interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 0. "   CP_FC_INTR_MASK583               ,frequency change done by cp interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"

group d:0xD4282874++0x03
    line.long 0x00 "PMU_CP_IRWC,PMU CP Interrupt READ/WRITE Clear Register"
        bitfld.long 0x00 25. " AP_C2_FC_DONE_INTR_IRST591      ,ap cluster2 frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 22. "         AP_CORE9_IDLE_WAKE_INTR_IRST593  ,<var processor: application> core9 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 21. "   AP_CORE8_IDLE_WAKE_INTR_IRST594      ,<var processor: application> core8 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 20. "   AP_C1_FC_DONE_INTR_IRST595       ,ap cluster1 frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "AP_CORE7_IDLE_WAKE_INTR_IRST596 ,<var processor: application> core7 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 18. "         AP_CORE6_IDLE_WAKE_INTR_IRST597  ,<var processor: application> core6 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 17. "   AP_CORE5_IDLE_WAKE_INTR_IRST598      ,<var processor: application> core5 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 16. "   AP_CORE4_IDLE_WAKE_INTR_IRST599  ,<var processor: application> core4 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "SP_CORE_IDLE_WAKE_INTR_IRST601  ,<var processor: <var processor: <var processor: <var processor: <var processor: <var processor: secure>>>>>> idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 10. "         AP_CORE3_IDLE_WAKE_INTR_IRST602  ,<var processor: application> core3 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 9. "   AP_CORE2_IDLE_WAKE_INTR_IRST603      ,<var processor: application> core2 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 8. "   AP_CORE1_IDLE_WAKE_INTR_IRST604  ,<var processor: application> core1 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "AP_CORE0_IDLE_WAKE_INTR_IRST605 ,<var processor: application> core0 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 6. "         CP_IDLE_WAKE_INTR_IRST606        ,cp idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 5. "   ACLK_FC_DONE_INTR_IRST607            ,aclk frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 4. "   DCLK_FC_DONE_INTR_IRST608        ,dclk frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "AP_C0_FC_DONE_INTR_IRST609      ,ap cluster0 frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 2. "         CP_FC_DONE_INTR_IRST610          ,cp frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 1. "   AP_FC_INTR_IRST611                   ,ap fc interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 0. "   CP_FC_INTR_IRST612               ,cp fc interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"

group d:0xD4282878++0x03
    line.long 0x00 "PMU_CP_ISR,PMU CP Interrupt Status Register"
        bitfld.long 0x00 25. " AP_C2_FC_DONE_INTR_ISR620       ,ap cluster2 frequency change done interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 22. "         AP_CORE9_IDLE_WAKE_INTR_ISR622   ,<var processor: application> core 9 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 21. "   AP_CORE8_IDLE_WAKE_INTR_ISR623       ,<var processor: application> core 8 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 20. "   AP_C1_FC_DONE_INTR_ISR624        ,ap cluster1 frequency change done interrupt status  1 = interrupt active" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "AP_CORE7_IDLE_WAKE_INTR_ISR625  ,<var processor: application> core 7 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 18. "         AP_CORE6_IDLE_WAKE_INTR_ISR626   ,<var processor: application> core 6 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 17. "   AP_CORE5_IDLE_WAKE_INTR_ISR627       ,<var processor: application> core 5 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 16. "   AP_CORE4_IDLE_WAKE_INTR_ISR628   ,<var processor: application> core 4 idle wake up interrupt status  1 = interrupt active" "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "SP_CORE_IDLE_WAKE_INTR_ISR630   ,<var processor: <var processor: <var processor: <var processor: <var processor: secure>>>>> idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 10. "         AP_CORE3_IDLE_WAKE_INTR_ISR631   ,<var processor: application> core 3 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 9. "   AP_CORE2_IDLE_WAKE_INTR_ISR632       ,<var processor: application> core 2 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 8. "   AP_CORE1_IDLE_WAKE_INTR_ISR633   ,<var processor: application> core 1 idle wake up interrupt status  1 = interrupt active" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "AP_CORE0_IDLE_WAKE_INTR_ISR634  ,<var processor: application> core 0 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 6. "         CP_IDLE_WAKE_INTR_ISR635         ,cp idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 5. "   ACLK_FC_DONE_INTR_ISR636             ,aclk frequency change done interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 4. "   DCLK_FC_DONE_INTR_ISR637         ,dclk frequency change done interrupt status  1 = interrupt active" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "AP_C0_FC_DONE_INTR_ISR638       ,ap cluster0 frequency change done interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 2. "         CP_FC_DONE_INTR_ISR639           ,cp frequency change done interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 1. "   AP_FC_ISR640                         ,ap fc interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 0. "   CP_FC_ISR641                     ,cp fc interrupt status  1 = interrupt active" "0,1"

group d:0xD428287C++0x03
    line.long 0x00 "PMU_SD_ROT_WAKE_CLR,SDIO/Rotary Wake Clear Register"
        bitfld.long 0x00 29.--31. " RSVD648                         ,reserve for future use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 28. "         USB_CHGDET_WK_STATUS             ,usb line charge detect wake up status" "0,1"
        bitfld.long 0x00 27. "   USB_ID_WK_STATUS                     ,usb line id wake up status" "0,1"
        bitfld.long 0x00 26. "   USB_VBUS_WK_STATUS               ,usb line vbus valid wake up status" "0,1"
        textline "                                      "
        bitfld.long 0x00 25. "USB_LINE1_WK_STATUS             ,usb line state1 wake up status" "0,1"
        bitfld.long 0x00 24. "         USB_LINE0_WK_STATUS              ,usb line state0 wake up status" "0,1"
        bitfld.long 0x00 21.--23. "   RSVD654                              ,reserve for future use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 20. "   USB_CHGDET_WK_CLR                ,usb line charge detect wake up clear  1 = clear   this bit is self-cleared by hardware" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "USB_ID_WK_CLR                   ,usb line id wake up clear  1 = clear   this bit is self-cleared by hardware" "0,1"
        bitfld.long 0x00 18. "         USB_VBUS_WK_CLR                  ,usb line vbus valid wake up clear  1 = clear   this bit is self-cleared by hardware" "0,1"
        bitfld.long 0x00 17. "   USB_LINE1_WK_CLR                     ,usb line state1 wake up clear  1 = clear   this bit is self-cleared by hardware" "0,1"
        bitfld.long 0x00 16. "   USB_LINE0_WK_CLR                 ,usb line state0 wake up clear  1 = clear   this bit is self-cleared by hardware" "0,1"
        textline "                                      "
        bitfld.long 0x00 14.--15. "RSVD660                         ,reserve for future use" "0,1,2,3"
        bitfld.long 0x00 12. "         USB_CHGDET_WK_MASK               ,usb line charge detect wake up enable  1 = enable" "0,1"
        bitfld.long 0x00 11. "   USB_ID_WK_MASK                       ,usb line id wake up enable  1 = enable" "0,1"
        bitfld.long 0x00 10. "   USB_VBUS_WK_MASK                 ,usb line vbus valid wake up enable  1 = enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 9. "USB_LINE1_WK_MASK               ,usb line state1 wake up enable  1 = enable" "0,1"
        bitfld.long 0x00 8. "         USB_LINE0_WK_MASK                ,usb line state0 wake up enable  1 = enable" "0,1"
        bitfld.long 0x00 7. "   CS_WK_STATUS                         ,cs wake up status" "0,1"
        bitfld.long 0x00 6. "   SDH2_WK_CLR                      ,sdh2 wake clear  1 = sdh2 wake event clear  this bit is self-cleared by hardware" "0,1"
        textline "                                      "
        bitfld.long 0x00 5. "CS_WK_CLR                       ,clear of dap power wake up request (dap csyspwrupreq)  1 = clear dap_req wakeup" "0,1"
        bitfld.long 0x00 4. "         CS_WK_MASK                       ,dap power wake up enable (dap csyspwrupreq)  1 = enable" "0,1"
        bitfld.long 0x00 3. "   KB_WK_CLR                            ,keypad wake clear  1 = rot wake event clear  this bit is self-cleared by hardware" "0,1"
        bitfld.long 0x00 2. "   ROT_WK_CLR                       ,rotary wake clear  1 = rot wake event clear  this bit is self-cleared by hardware" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "SDH1_WK_CLR                     ,sdh1 wake clear  1 = sdh1 wake event clear  this bit is self-cleared by hardware" "0,1"
        bitfld.long 0x00 0. "         SDH0_WK_CLR                      ,sdh0 wake clear  1 = sdh0 wake event clear  this bit is self-cleared by hardware" "0,1"

group d:0xD4282884++0x03
    line.long 0x00 "PMU_PWR_STBL_TIMER,Power Stable Timer Register"
        hexmask.long.byte 0x00 16.--23. 1. " PM_PWR_CLK_PRE683               ,clock prescaler for timer count  0x0 = divide by 1  0x1 = divide by 1  0x2 = divide by 2  all other values use an incremental divider."
        hexmask.long.byte 0x00 8.--15. 1. "        PM_PWR_UP_STBL_TIMER684          ,power up stable timer  stable time for power up during core idle mode in 26 mhz unit"
        hexmask.long.byte 0x00 0.--7. 1. "  PM_PWR_DWN_STBL_TIMER685             ,power down stable timer  stable time for the power down during core idle mode in 26 mhz unit"

group d:0xD4282888++0x03
    line.long 0x00 "PMU_DEBUG_REG,"
        bitfld.long 0x00 31. " MIPI_DSI_DPHY_VDD_DVM_VALID     ,mipi dsi dphy vdd dvm valid check  1 = mipi dsi dphy vdd dvm valid  0 = mipi dsi dphy vdd dvm invalid" "0,1"
        bitfld.long 0x00 30. "         AP_CORE_GBL_IRQ_MASK_CLR_DIS     ,<var processor: application> core gbl_irq_mask auto clear disable  pmu can auto clear the <var processor: application> core gbl_irq_mask to enable interrupt.  0 = auto clear function enabled  1 = auto clear function disabled" "0,1"
        bitfld.long 0x00 29. "   CP_GBL_IRQ_MASK_CLR_DIS              ,cp gbl_irq_mask auto clear disable  pmu can auto clear cp gbl_irq_mask to enable interrupt.  0 = auto clear function enabled  1 = auto clear function disabled" "0,1"
        bitfld.long 0x00 28. "   CP_HOT_RESET_PROT_EN             ,<var processor: comm> silent reset protection enable  1 = enable <var processor: comm> silent reset bus protection feature  0 = no bus protection, silent reset will reset <var processor: comm> right away" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "MASK_LCD_BLANK_CHECK            ,mask lcd blank check  this field is used for debug only - mask the lcd blank indication check for ddr frequency change.  1 = mask the lcd blank indication  0 = normal mode with lcd blank check." "0,1"
        bitfld.long 0x00 26. "         MIPI_CSI_DPHY_4LN_VDD_DVM_VALID  ,mipi csi 4 lane dphy vdd dvm valid check  1 = mipi 4 lane csi dphy vdd dvm valid  0 = mipi 4 lane csi dphy vdd dvm invalid" "0,1"
        bitfld.long 0x00 25. "   MIPI_CSI_DPHY_2LN_VDD_DVM_VALID      ,mipi dphy vdd dvm valid check  1 = mipi csi 2 lane dphy vdd dvm valid  0 = mipi 2 lane csi dphy vdd dvm invalid" "0,1"
        bitfld.long 0x00 24. "   FUNC_PLL_BYPASS                  ,func pll bypass  1 = 26 mhz  0 = 624 mhz" "0,1"
        textline "                                      "
        bitfld.long 0x00 23. "MASK_MC_SW_IDLE_INDICATION      ,mask memory controller software idle indication  debug only - mask the memory controller software idle indication check .  1 = mask the memory controller software idle indication during ap idle process.  0 = normal mode." "0,1"
        bitfld.long 0x00 22. "         AP_WFI_FC                        ,ap frequency change when in wfi  1 = allow a frequency change when core2 is in wfi  0 = do not allow a frequency change when core2 is in wfi" "0,1"
        bitfld.long 0x00 21. "   CP_WFI_FC                            ,cp frequency change when in wfi  1 = allow frequency change when core1 is in wfi  0 = do not allow a frequency change when core1 is in wfi" "0,1"
        bitfld.long 0x00 20. "   MASK_MC_CLK_ON_CHECK             ,debug only - mask the memory controller clock on indication from the memory controller.  1 = mask the memory controller clock on indication  0 = normal mode." "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "MASK_MC_CLK_OFF_CHECK           ,debug only - mask the memory controller clock off indication from the memory controller .  1 = mask the memory controller clock off indication.  0 = normal mode." "0,1"
        bitfld.long 0x00 18. "         MASK_AP_JTAG_IDLE_INDICATION     ,debug only - mask the ap jtag idle indication check.  1 = mask the ap jtag idle indication.  0 = normal mode." "0,1"
        bitfld.long 0x00 17. "   MASK_CP_JTAG_IDLE_INDICATION         ,debug only - mask the cp jtag idle indication check.  1 = mask the cp jtag idle indication.  0 = normal mode." "0,1"
        bitfld.long 0x00 16. "   MASK_MAIN_CLK_ON_CHECK           ,debug only - mask the main clock on indication check during ap idle process. if this bit is set then ap idle sequence will not wait for the acknowledge from main clock on indication.  1 = mask the mc idle indication during ap idle process. 0 = normal mod" "0,1"
        textline "                                      "
        bitfld.long 0x00 15. "MASK_MAIN_CLK_OFF_CHECK         ,debug only - mask the main clock off indication check during ap idle process. if this bit is set then ap idle sequence will not wait for the acknowledge from main clock off indication.  1 = mask the memory controller idle indication during ap idle proces" "0,1"
        bitfld.long 0x00 14. "         MASK_MC_IDLE_INDICATION          ,debug only - mask the memory controller idle indication check during ap idle process. if this bit is set then ap idle sequence will not wait for the acknowledge from memory controller idle indication.1 = mask the memory controller idle indication during a" "0,1"
        bitfld.long 0x00 13. "   MASK_DMA_IDLE_INDICATION             ,debug only - mask the dma idle indication check during ap idle process. if this bit is set then ap idle sequence will not wait for the acknowledge from dma idle indication.1 = mask the dma idle indication during ap idle process.0 = normal mode." "0,1"
        bitfld.long 0x00 12. "   MASK_AP_IDLE_IND                 ,debug only - mask the ap idle indication check during ap idle process. if this bit is set then ap idle sequence will not wait for the acknowledge from ap idle indication.  1 = mask the ap idle indication during ap idle process.  0 = normal mode." "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "MASK_CP_IDLE_IND                ,debug only - mask the cp idle indication check during ap idle process. if this bit is set then ap idle sequence will not wait for the acknowledge from cp idle indication.  1 = mask the cp idle indication during ap idle process.  0 = normal mode." "0,1"
        bitfld.long 0x00 10. "         MASK_AP_CLK_ON_ACK_FOR_IDLE      ,debug only - mask the ap clock on acknowledge from the ap clock generation unit during core idle process. if this bit is set then core idle sequence will not wait for the acknowledge from ap clock generator.  1 = mask the ap clock on acknowledge during c" "0,1"
        bitfld.long 0x00 9. "   MASK_AP_CLK_OFF_ACK_FOR_IDLE         ,debug only - mask the ap clock off acknowledge from the ap clock generation unit during core idle process. if this bit is set then core idle sequence will not wait for the acknowledge from ap clock generator.  1 = mask the ap clock off acknowledge during" "0,1"
        bitfld.long 0x00 8. "   MASK_CP_CLK_ON_ACK_FOR_IDLE      ,debug only - mask the cp clock on acknowledge from the cp clock generation unit during core idle process. if this bit is set then core idle sequence will not wait for the acknowledge from cp clock generator.  1 = mask the cp clock on acknowledge during c" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "MASK_CP_CLK_OFF_ACK_FOR_IDLE    ,debug only - mask the cp clock off acknowledge from the cp clock generation unit during core idle process. if this bit is set then core idle sequence will not wait for the acknowledge from cp clock generator.  1 = mask the cp clock off acknowledge during" "0,1"
        bitfld.long 0x00 6. "         MASK_ACLK_CLK_OFF_ACK            ,debug only - mask the aclk clock off acknowledge from the cp clock generation unit during frequency change process. if this bit is set then frequency change sequence will not wait for the acknowledge from aclk clock generator.  1 = mask the aclk clock of" "0,1"
        bitfld.long 0x00 5. "   MASK_DCLK_CLK_OFF_ACK                ,debug only - mask the dclk clock off acknowledge from the cp clock generation unit during frequency change process. if this bit is set then frequency change sequence will not wait for the acknowledge from dclk clock generator.  1 = mask the dclk clock of" "0,1"
        bitfld.long 0x00 4. "   MASK_AP_CLK_OFF_ACK              ,debug only - mask the ap clock off acknowledge from the cp clock generation unit during frequency change process. if this bit is set then frequency change sequence will not wait for the acknowledge from ap clock generator.  1 = mask the ap clock off ackn" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "MASK_CP_CLK_OFF_ACK             ,debug only - mask the cp clock off acknowledge from the cp clock generation unit during frequency change process. if this bit is set then frequency change sequence will not wait for the acknowledge from cp clock generator.  1 = mask the cp clock off ackn" "0,1"
        bitfld.long 0x00 2. "         MASK_MC_HALT                     ,debug only - mask the halt acknowledge from the memory controller during frequency change process. if this bit is set then frequency change sequence will not wait for the acknowledge from memory controller halt request.  1 = mask the halt acknowledge wai" "0,1"
        bitfld.long 0x00 1. "   MASK_AP_HALT                         ,debug only - mask the halt acknowledge from the ap during frequency change process. if this bit is set then frequency change sequence will not wait for the acknowledge from ap halt request.  1 = mask the halt acknowledge wait during frequency change proc" "0,1"
        bitfld.long 0x00 0. "   MASK_CP_HALT                     ,debug only - mask the halt acknowledge from the cp during frequency change process. if this bit is set then frequency change sequence will not wait for the acknowledge from cp halt request.  1 = mask the halt acknowledge wait during frequency change proc" "0,1"

group d:0xD428288C++0x03
    line.long 0x00 "PMU_SRAM_PWR_DWN,Core SRAM Power Down Register"
        bitfld.long 0x00 21. " CP_L2_LOW_LEAKAGE_EN            ,cp l2 cache ram power down in software mode  1 = sram power down  0 = sram active" "0,1"
        bitfld.long 0x00 20. "         CP_L2_LOW_LEAKAGE_DIS            ,cp l2 cache ram power down hardware control disable  1 = software control  0 = hardware control" "0,1"
        bitfld.long 0x00 19. "   AP_L2_LOW_LEAKAGE_EN                 ,ap l2 cache ram power down in software mode  1 = sram power down  0 = sram active" "0,1"
        bitfld.long 0x00 18. "   AP_L2_LOW_LEAKAGE_DIS            ,ap l2 cache ram power down hardware control disable  1 = software control  0 = hardware control" "0,1"
        textline "                                      "
        bitfld.long 0x00 17. "SQU_SRAM_PDWN_CP                ,squ sram power down from cp  1 = sram power down  0 = sram active" "0,1"
        bitfld.long 0x00 16. "         SQU_SRAM_PDWN_AP                 ,squ sram power down from ap  1 = sram power down  0 = sram active" "0,1"
        bitfld.long 0x00 9. "   AP_L1_LOW_LEAKAGE_EN                 ,ap l1 cache ram power down in software mode  1 = sram power down  0 = sram active" "0,1"
        bitfld.long 0x00 8. "   AP_L1_LOW_LEAKAGE_DIS            ,ap l1 cache ram power down hardware control disable  1 = software control  0 = hardware control" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "CP_L1_LOW_LEAKAGE_EN            ,cp l1 cache ram power down in software mode  1 = sram power down  0 = sram active" "0,1"
        bitfld.long 0x00 0. "         CP_L1_LOW_LEAKAGE_DIS            ,cp l1 cache ram power down hardware control disable  1 = software control  0 = hardware control" "0,1"

group d:0xD4282890++0x03
    line.long 0x00 "PMU_CORE_STATUS,Core Status Register"
        bitfld.long 0x00 31. " AP_CORE7_C2                     ,<var processor: application> core7 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core7 is in c2 mode.  1 = <var processor: application> core7 is in c2 mode" "0,1"
        bitfld.long 0x00 30. "         AP_CORE7_C1                      ,<var processor: application> core7 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core7 is in c1 mode.  1 = <var processor: application> core7 is in c1 mode (here c1 means external idle mode)" "0,1"
        bitfld.long 0x00 29. "   AP_CORE7_WFI_FLAG                    ,<var processor: application> core7 wfi flag  this field reflects the wfi flag that is generated by core7. when core7 enters wfi, this field will be set.." "0,1"
        bitfld.long 0x00 28. "   AP_CORE6_C2                      ,<var processor: application> core6 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core6 is in c2 mode.  1 = <var processor: application> core6 is in c2 mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "AP_CORE6_C1                     ,<var processor: application> core6 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core6 is in c1 mode.  1 = <var processor: application> core6 is in c1 mode (here c1 means external idle mode)" "0,1"
        bitfld.long 0x00 26. "         AP_CORE6_WFI_FLAG                ,<var processor: application> core6 wfi flag  this field reflects the wfi flag that is generated by core6. when core6 enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 25. "   AP_CORE5_C2                          ,<var processor: application> core5 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core5 is in c2 mode.  1 = <var processor: application> core5 is in c2 mode" "0,1"
        bitfld.long 0x00 24. "   AP_CORE5_C1                      ,<var processor: application> core5 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core5 is in c1 mode.  1 = <var processor: application> core5 is in c1 mode (here c1 means external idle mode)" "0,1"
        textline "                                      "
        bitfld.long 0x00 23. "AP_CORE5_WFI_FLAG               ,<var processor: application> core5 wfi flag  this field reflects the wfi flag that is generated by core5. when core5 enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 22. "         AP_CORE4_C2                      ,<var processor: application> core4 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core4 is in c2 mode.  1 = <var processor: application> core4 is in c2 mode" "0,1"
        bitfld.long 0x00 21. "   AP_CORE4_C1                          ,<var processor: application> core4 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core4 is in c1 mode.  1 = <var processor: application> core4 is in c1 mode (here c1 means external idle mode)" "0,1"
        bitfld.long 0x00 20. "   AP_CORE4_WFI_FLAG                ,<var processor: application> core4 wfi flag  this field reflects the wfi flag that is generated by core4. when core4 enters wfi, this field will be set." "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "AP_C1_MPSUB_M2                  ,<q><var processor: application mp> cluster1 subsystem idle mode<\q> indication  this field is used to indicate whether or not the <var processor: application mp> subsystem is in m2 mode.  1 = <var processor: application mp> subsystem is in m2 mode" "0,1"
        bitfld.long 0x00 18. "         AP_C1_MPSUB_M1                   ,<var processor: application mp> cluster1 subsystem in m1 mode indication  this field is used to indicate whether or not the <var processor: application mp> subsystem is in m1 mode.  1 = <var processor: application mp> subsystem is in m1 mode (here m1 means <var processor: application mp> subsystem external idle mode)" "0,1"
        bitfld.long 0x00 17. "   AP_C1_MPSUB_IDLE_FLAG                ,<var processor: application mp> cluster1  subsystem idle flag  this field reflects the and logic value of scu_idle and l2clkstopped generated in the <var processor: application mp> subsystem.  1 = core0/core1/core2/core3/scu/l2 are all in idle state" "0,1"
        bitfld.long 0x00 16. "   SP_IDLE                          ,<var processor: <var processor: <var processor: <var processor: <var processor: secure>>>>> 'core idle mode' indication  this field is used to indicate whether or not <var processor: <var processor: <var processor: <var processor: secure>>>> core is in 'core idle mode' mode.  1 = <var processor: <var processor: <var processor: <var processor: secure>>>> core is in core idle mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 15. "AP_CORE3_C2                     ,<var processor: application> core3 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core3 is in c2 mode.  1 = <var processor: application> core3 is in c2 mode" "0,1"
        bitfld.long 0x00 14. "         AP_CORE3_C1                      ,<var processor: application> core3 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core3 is in c1 mode.  1 = <var processor: application> core3 is in c1 mode (here c1 means external idle mode)" "0,1"
        bitfld.long 0x00 13. "   AP_CORE3_WFI_FLAG                    ,<var processor: application> core3 wfi flag  this field reflects the wfi flag that is generated by core3. when core3 enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 12. "   AP_CORE2_C2                      ,<var processor: application> core2 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core2 is in c2 mode.  1 = <var processor: application> core2 is in c2 mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "AP_CORE2_C1                     ,<var processor: application> core2 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core2 is in c1 mode.  1 = <var processor: application> core2 is in c1 mode (here c1 means external idle mode)" "0,1"
        bitfld.long 0x00 10. "         AP_CORE2_WFI_FLAG                ,<var processor: application> core2 wfi flag  this field reflects the wfi flag that is generated by core2. when core2 enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 9. "   AP_CORE1_C2                          ,<var processor: application> core1 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core1 is in c2 mode.  1 = <var processor: application> core1 is in c2 mode" "0,1"
        bitfld.long 0x00 8. "   AP_CORE1_C1                      ,<var processor: application> core1 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core1 is in c1 mode.  1 = <var processor: application> core1 is in c1 mode (here c1 means external idle mode)" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "AP_CORE1_WFI_FLAG               ,<var processor: application> core1 wfi flag  this field reflects the wfi flag that is generated by core1. when core1 enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 6. "         AP_CORE0_C2                      ,<var processor: application> core0 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core0 is in c2 mode.  1 = <var processor: application> core0 is in c2 mode" "0,1"
        bitfld.long 0x00 5. "   AP_CORE0_C1                          ,<var processor: application> core0 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core0 is in c1 mode.  1 = <var processor: application> core0 is in c1 mode (here c1 means external idle mode)" "0,1"
        bitfld.long 0x00 4. "   AP_CORE0_WFI_FLAG                ,<var processor: application> core0 wfi flag  this field reflects the wfi flag that is generated by core0. when core0 enters wfi, this field will be set." "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "AP_C0_MPSUB_M2                  ,<q><var processor: application mp> cluster0 subsystem idle mode<\q> indication  this field is used to indicate whether or not the <var processor: application mp> subsystem is in m2 mode.  1 = <var processor: application mp> subsystem is in m2 mode" "0,1"
        bitfld.long 0x00 2. "         AP_C0_MPSUB_M1                   ,<var processor: application mp> cluster0 subsystem in m1 mode indication  this field is used to indicate whether or not the <var processor: application mp> subsystem is in m1 mode.  1 = <var processor: application mp> subsystem is in m1 mode (here m1 means <var processor: application mp> subsystem external idle mode)" "0,1"
        bitfld.long 0x00 1. "   AP_C0_MPSUB_IDLE_FLAG                ,<var processor: application mp> cluster0  subsystem idle flag  this field reflects the and logic value of scu_idle and l2clkstopped generated in the <var processor: application mp> subsystem.  1 = core0/core1/core2/core3/scu/l2 are all in idle state" "0,1"

group d:0xD4282894++0x03
    line.long 0x00 "PMU_RES_FRM_SLP_CLR,Resume from Sleep Clear Register"
        bitfld.long 0x00 0. " CLR_RSM_FRM_SLP                 ,clear resume from sleep indication  1 = clear the status signal in ciu sys_boot_cntr[14]" "0,1"

group d:0xD4282898++0x03
    line.long 0x00 "PMU_AP_IMR,PMU AP Interrupt Mask Register"
        bitfld.long 0x00 25. " AP_C2_FC_DONE_INTR_MASK         ,debug only: frequency change done for ap cluster2 interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 22. "         AP_CORE9_IDLE_WAKE_INTR_MASK800  ,debug only: <var processor: application> core9 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 21. "   AP_CORE8_IDLE_WAKE_INTR_MASK801      ,debug only: <var processor: application> core8 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 20. "   AP_C1_FC_DONE_INTR_MASK          ,debug only: frequency change done for ap cluster1 interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "AP_CORE7_IDLE_WAKE_INTR_MASK803 ,debug only: <var processor: application> core7 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 18. "         AP_CORE6_IDLE_WAKE_INTR_MASK804  ,debug only: <var processor: application> core6 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 17. "   AP_CORE5_IDLE_WAKE_INTR_MASK805      ,debug only: <var processor: application> core5 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 16. "   AP_CORE4_IDLE_WAKE_INTR_MASK806  ,debug only: <var processor: application> core4 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "SP_CORE_IDLE_WAKE_INTR_MASK808  ,debug only: <var processor: <var processor: <var processor: <var processor: <var processor: secure>>>>> idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 10. "         AP_CORE3_IDLE_WAKE_INTR_MASK809  ,debug only: <var processor: application> core3 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 9. "   AP_CORE2_IDLE_WAKE_INTR_MASK810      ,debug only: <var processor: application> core2 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 8. "   AP_CORE1_IDLE_WAKE_INTR_MASK811  ,debug only: <var processor: application> core1 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "AP_CORE0_IDLE_WAKE_INTR_MASK812 ,debug only: <var processor: application> core0 idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 6. "         CP_IDLE_WAKE_INTR_MASK813        ,debug only: cp idle wake up interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 5. "   ACLK_FC_DONE_INTR_MASK814            ,debug only: aclk frequency change done interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 4. "   DCLK_FC_DONE_INTR_MASK815        ,debug only: dclk frequency change done interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "AP_C0_FC_DONE_INTR_MASK         ,debug only: frequency change done for ap cluster0 interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 2. "         CP_FC_DONE_INTR_MASK817          ,debug only: frequency change done for cp interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 1. "   AP_FC_INTR_MASK                      ,ap fc interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"
        bitfld.long 0x00 0. "   CP_FC_INTR_MASK819               ,frequency change done by cp interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"

group d:0xD428289C++0x03
    line.long 0x00 "PMU_AP_IRWC,PMU AP Interrupt READ/WRITE Clear Register"
        bitfld.long 0x00 25. " AP_C2_FC_DONE_INTR_IRST827      ,ap cluster2 frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 22. "         AP_CORE9_IDLE_WAKE_INTR_IRST829  ,<var processor: application> core9 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 21. "   AP_CORE8_IDLE_WAKE_INTR_IRST830      ,<var processor: application> core8 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 20. "   AP_C1_FC_DONE_INTR_IRST831       ,ap cluster1 frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "AP_CORE7_IDLE_WAKE_INTR_IRST832 ,<var processor: application> core7 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 18. "         AP_CORE6_IDLE_WAKE_INTR_IRST833  ,<var processor: application> core6 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 17. "   AP_CORE5_IDLE_WAKE_INTR_IRST834      ,<var processor: application> core5 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 16. "   AP_CORE4_IDLE_WAKE_INTR_IRST835  ,<var processor: application> core4 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "SP_CORE_IDLE_WAKE_INTR_IRST837  ,<var processor: secure> wake up interrupt read clear  wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 10. "         AP_CORE3_IDLE_WAKE_INTR_IRST838  ,<var processor: application> core3 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 9. "   AP_CORE2_IDLE_WAKE_INTR_IRST839      ,<var processor: application> core2 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 8. "   AP_CORE1_IDLE_WAKE_INTR_IRST840  ,<var processor: application> core1 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "AP_CORE0_IDLE_WAKE_INTR_IRST841 ,<var processor: application> core0 idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 6. "         CP_IDLE_WAKE_INTR_IRST842        ,cp idle wake up interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 5. "   ACLK_FC_DONE_INTR_IRST843            ,aclk frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 4. "   DCLK_FC_DONE_INTR_IRST844        ,dclk frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "AP_C0_FC_DONE_INTR_IRST845      ,ap cluster0 frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 2. "         CP_FC_DONE_INTR_IRST846          ,cp frequency change done interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 1. "   AP_FC_INTR_IRST847                   ,ap fc interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"
        bitfld.long 0x00 0. "   CP_FC_INTR_IRST848               ,cp fc interrupt read clear  1 = read clear  0 = interrupt write clear" "0,1"

group d:0xD42828A0++0x03
    line.long 0x00 "PMU_AP_ISR,PMU AP Interrupt Status Register"
        bitfld.long 0x00 25. " AP_C2_FC_DONE_INTR_ISR856       ,ap cluster2 frequency change done interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 22. "         AP_CORE9_IDLE_WAKE_INTR_ISR858   ,<var processor: application> core 9 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 21. "   AP_CORE8_IDLE_WAKE_INTR_ISR859       ,<var processor: application> core 8 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 20. "   AP_C1_FC_DONE_INTR_ISR860        ,ap cluster1 frequency change done interrupt status  1 = interrupt active" "0,1"
        textline "                                      "
        bitfld.long 0x00 19. "AP_CORE7_IDLE_WAKE_INTR_ISR861  ,<var processor: application> core 7 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 18. "         AP_CORE6_IDLE_WAKE_INTR_ISR862   ,<var processor: application> core 6 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 17. "   AP_CORE5_IDLE_WAKE_INTR_ISR863       ,<var processor: application> core 5 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 16. "   AP_CORE4_IDLE_WAKE_INTR_ISR864   ,<var processor: application> core 4 idle wake up interrupt status  1 = interrupt active" "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "SP_CORE_IDLE_WAKE_INTR_ISR866   ,sp core idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 10. "         AP_CORE3_IDLE_WAKE_INTR_ISR867   ,<var processor: application> core 3 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 9. "   AP_CORE2_IDLE_WAKE_INTR_ISR868       ,<var processor: application> core 2 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 8. "   AP_CORE1_IDLE_WAKE_INTR_ISR869   ,<var processor: application> core 1 idle wake up interrupt status  1 = interrupt active" "0,1"
        textline "                                      "
        bitfld.long 0x00 7. "AP_CORE0_IDLE_WAKE_INTR_ISR870  ,<var processor: application> core 0 idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 6. "         CP_IDLE_WAKE_INTR_ISR871         ,cp idle wake up interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 5. "   ACLK_FC_DONE_INTR_ISR872             ,aclk frequency change done interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 4. "   DCLK_FC_DONE_INTR_ISR873         ,dclk frequency change done interrupt status  1 = interrupt active" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "AP_C0_FC_DONE_INTR_ISR874       ,ap cluster0 frequency change done interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 2. "         CP_FC_DONE_INTR_ISR875           ,cp frequency change done interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 1. "   AP_FC_ISR876                         ,ap fc interrupt status  1 = interrupt active" "0,1"
        bitfld.long 0x00 0. "   CP_FC_ISR877                     ,cp fc interrupt status  1 = interrupt active" "0,1"

group d:0xD42828A4++0x03
    line.long 0x00 "PMU_VPU_CLK_RES_CTRL,VPU Clock/Reset Control Register"
        bitfld.long 0x00 21. " VPU_CLK_FC_REQ                  ,vpu  clk frequency change request  write 1 to trigger a frequency change. this field is hardware cleared when the frequency change completes." "0,1"
        bitfld.long 0x00 20. "         VPU_FUSE_LOAD_MASK               ,only for debug to set" "0,1"
        bitfld.long 0x00 19. "   VPU_HW_MODE                          ,vpu hardware on/off mode" "0,1"
        bitfld.long 0x00 18. "   VPU_SLEEP2                       ,vpu power switch sleep2" "0,1"
        textline "                                      "
        bitfld.long 0x00 17. "VPU_SLEEP1                      ,vpu power switch sleep1" "0,1"
        bitfld.long 0x00 16. "         VPU_ISOB                         ,vpu isolation wrapper  0 = enable isolation (vpu power-down mode)  1 = disable isolation (vpu active mode)" "0,1"
        bitfld.long 0x00 13.--15. "   VPU_CLK_DIV                          ,vpu func clock divide ratio  vpu_clk = vpu_clk_sel / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 10.--12. "   VPU_CLK_SEL                      ,vpu func clock select  0x0 = pll1 624 mhz  0x1 = pll1 499 mhz  0x2 = pll1 832mhx  0x3 = pll3_div3 0x4 = pll3_div2 0x5 = pll4_div2 0x6 = pll5_div2 0x7 = pll1 1248mhz" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 3. "VPU_CLK_EN                      ,vpu func clock enable  1 =  clock enabled  0 =  clock disabled" "0,1"
        bitfld.long 0x00 0. "         VPU_RST                          ,vpu  reset" "0,1"

group d:0xD42828AC++0x03
    line.long 0x00 "PMU_DTC_CLK_RES_CTRL,DTC Clock/Reset Control Register"
        bitfld.long 0x00 3. " DTC_AXICLK_EN                   ,dtc axi clock enable  1 = axi clock enabled  0 = axi clock disabled" "0,1"
        bitfld.long 0x00 0. "         DTC_AXI_RST                      ,dtc axi reset" "0,1"

group d:0xD42828B0++0x03
    line.long 0x00 "PMU_MC_HW_SLP_TYPE,Memory Controller Hardware Sleep Type Register"
        bitfld.long 0x00 11. " 4X_CLK_MODE915                  ,4x clk mode  enabled 4:1 dclk mode" "0,1"
        bitfld.long 0x00 10. "         MC_REG_TABLE_EN                  ,enable ffc ddr clock change.  0 = enable, 1 = disable" "0,1"
        bitfld.long 0x00 9. "   2X_CLK_MODE                          ,2x clk mode  enabled 2x dclk for ddr freq_ratio=1:1" "0,1"
        bitfld.long 0x00 8. "   MC_TB0_MASK                      ,memory controller table0 operation  with this field, sleep mode exit can automatically trigger memory controller table0 operation.  0 = enable  1 = disable please keep default value" "0,1"
        textline "                                      "
        bitfld.long 0x00 3.--7. "MC_REG_TABLE_NUM                ,memory controller register table number  valid values are from 0x0 to 0x1f. this is used for table-based ddr clock change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

group d:0xD42828B4++0x03
    line.long 0x00 "PMU_MC_SLP_REQ_AP,Memory Controller AP Sleep Request Register"
        bitfld.long 0x00 1. " MC_SLP_ACK928                   ,memory controller low power acknowledge .  1 = memory controller in low power mode." "0,1"
        bitfld.long 0x00 0. "         MC_SLP_REQ_AP                    ,memory controller <var processor: application mp> sleep request  this field is used for <var processor: application mp> request to the memory controller to enter into sleep mode.  1 = <var processor: application mp> allows mc to enter into sleep mode" "0,1"

group d:0xD42828B8++0x03
    line.long 0x00 "PMU_MC_SLP_REQ_CP,Memory Controller <var Processor: Comm> Sleep Request Register"
        bitfld.long 0x00 1. " MC_SLP_ACK937                   ,memory controller low power acknowledge .  1 = memory controller in low power mode." "0,1"
        bitfld.long 0x00 0. "         MC_SLP_REQ_CP                    ,memory controller <var processor: comm> sleep request  this field is used for <var processor: comm> request to the memory controller to enter into sleep mode.  1 = <var processor: comm> allows mc to enter into sleep mode." "0,1"

group d:0xD42828BC++0x03
    line.long 0x00 "PMU_MC_SLP_REQ_MSA,Memory Controller MSA Sleep Request Register"
        bitfld.long 0x00 1. " MC_SLP_ACK946                   ,memory controller low power acknowledge .  1 = memory controller in low power mode." "0,1"
        bitfld.long 0x00 0. "         MC_SLP_REQ_MSA                   ,memory controller msa sleep request  this field is used for msa request to the mc to enter into sleep mode.  1 = msa allows mc to enter into sleep mode." "0,1"

group d:0xD42828C0++0x03
    line.long 0x00 "PMU_MC_SW_SLP_TYPE,Memory Controller Software Sleep Type Register"
        bitfld.long 0x00 0.--2. " MC_SW_SLP_TYPE                  ,software controlled sleep type for memory controller  0x0 = self refresh power down  0x1 = active power down  0x2 = precharge power down  0x3 = deep power down" "0,1,2,3,4,5,6,7"

group d:0xD42828C4++0x03
    line.long 0x00 "PMU_PLL_SEL_STATUS,PLL Clock Select Status Register"
        bitfld.long 0x00 14.--16. " AP_C2_PLL_SEL                   ,<var processor: application> cluster2 core clock selection  0x0 = pll1 1248 mhz  0x1 = pll1 832 mhz     0x2= pll3_div2(1.05g)   0x3=pll2_div2          0x4=pll5_div1   0x5=pll6_div1      0x6=pll4_div1(1.75g)             0x7=pll3_div1(2.1g)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 11.--13. "         AP_C1_PLL_SEL                    ,<var processor: application> cluster1 core clock selection  0x0 = pll1 1248 mhz  0x1 = pll1 832 mhz     0x2= pll3_div2(1.05g)   0x3=pll2_div2   0x4=pll5_div1   0x5=pll6_div1   0x6=pll4_div1(1.75g)    0x7 = reserved" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 8.--10. "   AP_C0_PLL_SEL                        ,<var processor: application> cluster0 core clock selection  0x0 = pll1 624 mhz  0x1 = pll1 832 mhz     0x2= pll1 499mhz    0x3 = pll3_div2(1.05g)    0x4 = pll1 1248mhz     0x5~0x7 reserved" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 6.--7. "   ACLK_PLL_SEL                     ,bus clock pll select  0x0 = pll1 (416 mhz)  0x1 = pll1 (624 mhz)  0x2 = pll2out  0x3= pll2outp" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 3.--5. "DCLK_PLL_SEL                    ,ddr clock selection  0x7 = pll3 div2   0x6 = pll5 div2   0x4 = pll2 div2   0x5 = pll4 div2   0x0 = pll1 624 mhz  0x1 = pll1 832 mhz" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0.--2. "         CP_PLL_SEL                       ,<var processor: comm> pll select  0x0 = pll1 (416 mhz)  0x1 = pll1 (624 mhz)  0x2 = pll2out  0x3= pll1_312 mhz" "0,1,2,3,4,5,6,7"

group d:0xD42828CC++0x03
    line.long 0x00 "PMU_GPU_CLK_RES_CTRL,GPU Clock/Reset Control Register"
        bitfld.long 0x00 18.--20. " GPU_CLK_SEL                     ,gpu function clock select  0x0 = pll1 624 mhz  0x1 = pll1 499 mhz  0x2 = pll1 832mhz  0x3 = pll3_div3   0x4 = pll4_div2   0x5 = pll5_div2   0x6 = pll3_div2   0x7 = pll1 1248mhz" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 16. "         GPU_CLKMODE                      ,gpu function clk and bus clk frequency ratio.  0 = bus clk frequency equals function clk frequency.    1 = bus clk frequency is half of function clk frequency." "0,1"
        bitfld.long 0x00 15. "   GPU_FNC_FC_REQ                       ,gpu function clk frequency change request  write 1 to trigger a frequency change. this field is hardware cleared when the frequency change completes." "0,1"
        bitfld.long 0x00 12.--14. "   GPU_CLK_DIV                      ,gpu function clk divider  gpu_fnc_clk = gpu_clk_sel / (this field +1)" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 11. "PM_HW_MODE981                   ,hardware control mode for gpu power up and power down" "0,1"
        bitfld.long 0x00 10. "         GPU_SLEEP2                       ,gpu power switch sleep2" "0,1"
        bitfld.long 0x00 9. "   GPU_SLEEP1                           ,gpu power switch sleep1" "0,1"
        bitfld.long 0x00 8. "   GPU_ISOB                         ,gpu isolation wrapper  0 = enable isolation (gpu powr-down mode)  1 = disable isolation (gpu active mode)" "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "GPU_CLK_EN                      ,gpu functional clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        bitfld.long 0x00 1. "         GPU_RST1                         ,gpu peripheral reset 1  0 = reset" "0,1"

group d:0xD42828D4++0x03
    line.long 0x00 "PMUA_SMC_CLK_RES_CTRL,SMC Clock/Reset Control Register"
        bitfld.long 0x00 6.--7. " SMC_CLK_SEL                     ,smc peripheral clock select  0x0 = 62.4 mhz  0x1 = 31.2 mhz  0x2 = 78 mhz  0x3 = 104 mhz" "0,1,2,3"
        bitfld.long 0x00 4. "         SMC_CLK_EN                       ,smc peripheral clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        bitfld.long 0x00 3. "   SMC_AXICLK_EN                        ,smc axi clock enable  1 = axi clock enabled  0 = axi clock disabled" "0,1"
        bitfld.long 0x00 1. "   SMC_RST                          ,smc peripheral reset  0 = reset" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "SMC_AXI_RST                     ,smc axi reset" "0,1"

group d:0xD42828D8++0x03
    line.long 0x00 "PMUA_PWR_CTRL_REG,Power Control Register"
        bitfld.long 0x00 14. " VSP_AUTO_PWR_ON                 ,vsp auto power on  when asserted to 1, it triggers a request to power up the vsp power island  when de-asserted to 0, it triggers a request to power down vsp power, if vsp_clk_res_ctrl[27] is set" "0,1"
        bitfld.long 0x00 12. "         LCD_AUTO_PWR_ON                  ,lcd auto power on  1 = triggers request to power up the audio power island  0 = triggers request to power down audio power, if pmu_lcd_clk_rst_ctrl1[27] is set" "0,1"
        bitfld.long 0x00 10. "   AUDIO_AUTO_PWR_ON                    ,audio auto power on  1 = triggers request to power up the audio power island  0 = triggers request to power down audio power, if pmu_audio_cl[10] is set" "0,1"
        bitfld.long 0x00 4. "   ISP_AUTO_PWR_ON                  ,isp auto power on  when asserted to 1, it triggers a request to power up the isp power island  when de-asserted to 0, it triggers a request to power down isp power, if isp_clk_res_ctrl[15] is set" "0,1"
        textline "                                      "
        bitfld.long 0x00 2. "VPU_AUTO_PWR_ON                 ,vpu auto power on  when asserted to 1, it triggers a request to power up the vpu power island  when de-asserted to 0, it triggers a request to power down vpu power, if vpu_clk_res_ctrl[19] is set" "0,1"
        bitfld.long 0x00 0. "         GPU_AUTO_PWR_ON                  ,gpu auto power on  when asserted to 1, it triggers a request to power up the gpu power island  when de-asserted to 0, it triggers a request to power down gpu power, if gpu_clk_res_ctrl[11] is set" "0,1"

group d:0xD42828DC++0x03
    line.long 0x00 "PMUA_PWR_BLK_TMR_REG,Block Power Timer Register"
        hexmask.long.word 0x00 16.--31. 1. " PWR_ON1_TIMER                   ,gpu/vpu/isp/audio  auto-power on sleep1 to sleep2 delay"
        hexmask.long.byte 0x00 8.--15. 1. "      PWR_ON2_TIMER                    ,gpu/vpu/isp/audio auto-power on sleep2 to clock_en delay"
        hexmask.long.byte 0x00 0.--7. 1. "  PWR_OFF_TIMER                        ,gpu/vpu/isp/audio auto-power off sleep2 to sleep1 delay"

group d:0xD42828E0++0x03
    line.long 0x00 "PMUA_SDH2_CLK_RES_CTRL,SDH2 Clock/Reset Control Register"
        bitfld.long 0x00 11. " SDH2_CLK_FC_REQ                 ,sdh2 clock frequency change request  when this field is set to 1, it will force sdh2_clk_div to work. this field will be automatically cleared by hardware when clock switch is done." "0,1"
        bitfld.long 0x00 8.--10. "         SDH2_CLK_DIV                     ,sdh2 clock frequency divisor  0-7 =  sdh2_clk = sdh2 source clock/(sdh2_clk_div + 1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 6.--7. "   SDH2_CLK_SEL                         ,sdh0 clock source select   0=416mhz(clk_in_416m_pll1)   1=624mhz(clk_in_pll1_2x)   2=clk_in_pll6_div2   3=400mhz(clk_in_pll6_div4)" "0,1,2,3"
        bitfld.long 0x00 4. "   SDH2_CLK_EN                      ,sdh2 peripheral clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "SDH2_RST                        ,sdh2 peripheral reset  0 = reset" "0,1"

group d:0xD4282920++0x03
    line.long 0x00 "PMU_C0_CAPMP_IDLE_CFGx0,Cluster0 <var Processor: Application MP> Idle Configuration Register for Core x"

group d:0xD42828E4++0x03
    line.long 0x00 "PMU_C0_CAPMP_IDLE_CFGx1,Cluster0 <var Processor: Application MP> Idle Configuration Register for Core x"

group d:0xD4282950++0x03
    line.long 0x00 "PMU_C0_CAPMP_IDLE_CFGx2,Cluster0 <var Processor: Application MP> Idle Configuration Register for Core x"

group d:0xD4282954++0x03
    line.long 0x00 "PMU_C0_CAPMP_IDLE_CFGx3,Cluster0 <var Processor: Application MP> Idle Configuration Register for Core x"
        bitfld.long 0x00 19. " DIS_MP_L2_SLP1054               ,disable <var processor: application mp> l2 power switch  this field is used to disable the <var processor: application mp> l2 power switch sleep power down during <var processor: application mp> power down mode.  1 = disable <var processor: application" "0,1"
        bitfld.long 0x00 18. "         DIS_MP_SLP1055                   ,disable <var processor: application mp> power switch  this field is used to disable the <var processor: application mp> power switch sleep power down during mp subsystem power down mode.  1 = disable mp power switch sleep" "0,1"
        bitfld.long 0x00 16. "   MP_L2_PWR_OFF1057                    ,frc l2 sram off  1 = l2 cache power is off" "0,1"
        bitfld.long 0x00 13. "   L2_HW_CACHE_FLUSH_EN1059         ,l2 hardware cache flush enable  0x1= enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "MASK_SRAM_REPAIR_DONE_CHECK1060 ,mask sram repair done check  1 = mask sram repair done check" "0,1"
        bitfld.long 0x00 11. "         MASK_CLK_OFF_CHECK1061           ,mask <var processor: application mp> clock off state check  this field is used to mask the <var processor: application mp> clock off check during the mp idle process." "0,1"
        bitfld.long 0x00 10. "   MASK_CLK_STBL_CHECK1062              ,mask mp clock stbl state check  this field is used to mask the mp clock stable check during mp wakeup." "0,1"
        bitfld.long 0x00 9. "   MASK_JTAG_IDLE_CHECK1063         ,mask jtag idle state check  this field is used to mask the jtag idle check during <var processor: application mp> idle entry.  1 = mask jtag idle check" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "MASK_IDLE_CHECK1064             ,mask <var processor: application mp> idle state check  debug only - it should be 0 during normal operation  1 = status check masked  0 = status check not masked" "0,1"
        bitfld.long 0x00 7. "         ACINACTM_HW_CTRL1065             ,acinactm hardware control   0x0=low power state machine does not control acinactm port.   0x1= low power state machine will control acinactm port of <var processor: application mp>.  when m2/m1 low power mode is entered, acinactm port will be high" "0,1"
        bitfld.long 0x00 5. "   DIS_MC_SW_REQ1067                    ,disable memory controller software req  this field is used to disable the memory controller entry to idle mode using the memory controller sleep request bits. the memory controller will always enter into idle mode based upon the hardware state machine re" "0,1"
        bitfld.long 0x00 4. "   MP_WAKE_MC_EN1068                ,<var processor: application mp> wake mc enable  wake up the memory controller when the <var processor: application mp> wakes up from idle mode. the memory controller will be woken up before the interrupt to the core is released.  0 = memory controller w" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "MP_SCU_SRAM_PWRDWN1069          ,not used. scu sram does not support retention" "0,1"
        bitfld.long 0x00 3. "         PM_1070                          ,reserved for future use" "0,1"
        bitfld.long 0x00 2. "   L2_SRAM_PWRDWN1071                   ,l2 cache sram power down  this field does not take effect if mp_pwrdwn is 0.  1 = when <var processor: application mp> is idle, l2 sram power will be off  0 = when <var processor: application mp> is idle, l2 sram is in retention mode" "0,1"
        bitfld.long 0x00 1. "   MP_PWRDWN1072                    ,<var processor: application mp> power down  this field does not take effect if mp_idle is 0.  1 = when <var processor: application mp> is idle, <var processor: application mp> will go into deep sleep mode and <var processor: application mp> logic will b" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "MP_IDLE1073                     ,<var processor: application mp> idle  1 = when <var processor: application mp> is idle, <var processor: application mp> clocks will be gated externally" "0,1"

group d:0xD42828E8++0x03
    line.long 0x00 "PMUA_MC_CTRL,Memory Controller AHB Register"
        bitfld.long 0x00 29. " BYPS_DFI_INIT_HW                ,debug bit 1: bypass phy_arc_hw_en control of phy signals 0: no bypass, take effect when mc_core_init==0" "0,1"
        bitfld.long 0x00 28. "         BYPS_FREQ_HW                     ,debug bit 1: bypass core/dfi freq control by hardware 0: no bypass, take effect except audio init phy and core" "0,1"
        bitfld.long 0x00 27. "   MC_SEL_AUD_APB                       ,debug bit 1: select audio apb to mc core and phy apb 0: default way on memory map" "0,1"
        bitfld.long 0x00 26. "   BYPS_PHY_ARC_HW                  ,debug bit 1: bypass phy_arc_hw_en control of phy signals 0: no bypass, phy_arc_hw_en take effect when mc_phy_arc_hw==1&&mc_core_init==0" "0,1"
        textline "                                      "
        bitfld.long 0x00 25. "BYPS_DEASS_PWROK                ,debug bit 1: bypass deassert pwrok in main pmu when pll off 0: deassert pwrok in main pmu before pll off" "0,1"
        bitfld.long 0x00 24. "         MC_INIT_BYPASS                   ,debug bit 1: mc initiallization bypassed when low power exit 0: mc initiallization follow ap_idle_sm when low power exit" "0,1"
        bitfld.long 0x00 17. "   MC_DEASS_PWROK                       ,1: deassert pwrok for mc phy,  the bit would be cleared automatically" "0,1"
        bitfld.long 0x00 16. "   MC_ASS_PWROK                     ,1: assert pwrok for mc phy,  the bit would be cleared automatically" "0,1"
        textline "                                      "
        bitfld.long 0x00 14. "MC_PHY_ARC_HW                   ,1: hw override arc control: rst/stall/clken/cms to enable arc firmware executing when low power exit 0: no use arc hw control to enable firmware" "0,1"
        bitfld.long 0x00 13. "         MC_CORE_INIT                     ,1: init mc core when low power exit 0: init mc core bypassed when low power exit, if mc_init_bypass==0, only init mc phy" "0,1"
        bitfld.long 0x00 12. "   MC_INIT_BY_AUDIO                     ,1: mc initiallized by audio core when low power exit 0: mc initiallized by table when low power exit" "0,1"
        bitfld.long 0x00 9. "   MC_PHY_RSTN                      ,memory controller phy reset  0 = reset" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "MC_CORE_RSTN                    ,memory controller core reset  0 = reset" "0,1"
        bitfld.long 0x00 4. "         HW_DRAIN_CAM                     ,1: drive csysdiscamdrain==1 to memory controller when hwffc 0:" "0,1"
        bitfld.long 0x00 3. "   DTE_AHBCLK_EN                        ,dte ahbi clock enable  1 = ahb clock enabled  0 = ahb clock disabled" "0,1"
        bitfld.long 0x00 2. "   DTE_HCLK_RST                     ,dte hclk reset: 0 = reset" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "MCK5_AHBCLK_EN                  ,memory controller ahb clock enable  1 = ahb clock enabled  0 = ahb clock disabled" "0,1"
        bitfld.long 0x00 0. "         MCK5_HCLK_RST                    ,memory controller hclk reset  0 = reset" "0,1"

group d:0xD42828F0++0x03
    line.long 0x00 "PMUA_PWR_STATUS_REG,Power Status Register"
        bitfld.long 0x00 12. " LCD_PWR_STAT                    ,hw updated status of pwr_ctrl[12] when the lcd has entered/exit its lpm." "0,1"
        bitfld.long 0x00 10. "         AUDIO_PWR_STAT                   ,audio power state update  hardware updated status of pwr_ctrl[10] when the audio has entered/exit its lpm.  0x0 = audio is powered off  0x1 = audio is powered on" "0,1"
        bitfld.long 0x00 9. "   GNSS_SD_PWR_STAT1114                 ,gnss domain power state  before turning off gnss_aon power, software must ensure gnss_sd power is off by polling this bit.  0x0 = gnss_sd is powered off  0x1 = gnss_sd is powered on" "0,1"
        bitfld.long 0x00 8. "   GNSS_PWR_STAT1115                ,gnss power state update  hardware updated status of pwr_ctrl[8] when the gnss has entered/exit its lpm.  0x0 = gnss is powered off  0x1 = gnss is powered on" "0,1"
        textline "                                      "
        bitfld.long 0x00 9. "GNSS_SD_PWR_STAT1116            ,gnss domain power state  before turning off gnss_aon power, software must ensure gnss_sd power is off by polling this bit.  0x0 = gnss_sd is powered off  0x1 = gnss_sd is powered on" "0,1"
        bitfld.long 0x00 8. "         GNSS_PWR_STAT1117                ,gnss power state update  hardware updated status of pwr_ctrl[8] when the gnss has entered/exit its lpm.  0x0 = gnss is powered off  0x1 = gnss is powered on" "0,1"
        bitfld.long 0x00 4. "   ISP_PWR_STAT                         ,hw updated status of pwr_ctrl[4] when the isp has entered/exit its lpm." "0,1"
        bitfld.long 0x00 2. "   VPU_PWR_STAT                     ,hw updated status of pwr_ctrl[2] when the vpu has entered/exit its lpm." "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "GPU_PWR_STAT                    ,hw updated status of pwr_ctrl[0] when the gpu has entered/exit its lpm." "0,1"

group d:0xD42828F8++0x03
    line.long 0x00 "PMU_SP_IDLE_CFG,SP Idle Configuration Register"
        bitfld.long 0x00 4. " MASK_SP_IDLE_IND                ,mask <var processor: secure> idle indication  debug only - mask the <var processor: secure> idle indication check during ap/cp idle process. if this bit is set, then ap/cp idle sequence does not wait for acknowledgement from the <var processor: secure> i" "0,1"
        bitfld.long 0x00 3. "         SP_GBL_IRQ_MASK_CLR_DIS          ,sp gbl_irq_mask auto clear disable  pmu can auto clear sp gbl_irq_mask to enable interrupt.  0 = auto clear function enabled  1 = auto clear function disabled" "0,1"
        bitfld.long 0x00 2. "   MASK_SP_CLK_ON_CHECK                 ,mask <var processor: secure> clock on check  debug only - mask the <var processor: secure> clock on indication check during <var processor: secure> idle process. if this bit is set, then the <var processor: secure> idle sequence does not wait for acknowl" "0,1"
        bitfld.long 0x00 1. "   MASK_SP_CLK_OFF_ACK              ,mask <var processor: secure> clock off acknowledge  debug only - mask the <var processor: secure> clock off acknowledge from the <var processor: secure> clock generation unit  1 = mask the cp clock off acknowledge during frequency change process  0 = n" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "MASK_WFI_CHECK1135              ,wfi state check mask  debug only - it should be 0 during normal operation  1 = status check masked  0 = status check not masked" "0,1"

group d:0xD42828FC++0x03
    line.long 0x00 "PMU_GNSS_PWR_CTRL,GNSS Power Control Register"
        bitfld.long 0x00 9. " GNSS_RST_STATUS                 ,gnss reset status    0x0 = gnss is in reset state   0x1 = gnss reset  is released" "0,1"
        bitfld.long 0x00 8. "         GNSS_SILENT_RST_MODE             ,gnss reset mode slect.  this select only take effect when gnss_hiw_mode is 0. when gnss_hw_mode is 1, gnss reset mode is always normal mode   0x0 = gnss reset mode is normal mode   0x1 = gnss reset mode is silent reset mode. reset is asserted only when gnss bus interface is idle" "0,1"
        bitfld.long 0x00 7. "   GNSS_ACLK_EN                         ,gnss axi clock enable  0x0 = gnss axi clock is disabled  0x1 = gnss axi clock is enabled" "0,1"
        bitfld.long 0x00 6. "   GNSS_FUSE_LOAD_MASK              ,gnss fuse load mask  debug only  0x0 = no mask  0x1 = mask fuse load done check" "0,1"
        textline "                                      "
        bitfld.long 0x00 5. "GNSS_FUSE_LOAD_START            ,gnss fuse load start  note that when gnss fuse loading finishes, this field is automatically cleared by hardware logic.  0x0 = don't trigger gnns fuse loading or fuse loading has finished  0x1 = trigger gnns fuse loading" "0,1"
        bitfld.long 0x00 4. "         GNSS_SLEEP2                      ,gnss power switch sleep2" "0,1"
        bitfld.long 0x00 3. "   GNSS_SLEEP1                          ,gnss power switch sleep1" "0,1"
        bitfld.long 0x00 2. "   GNSS_ISOB                        ,gnss isolation control  0x0 = enable isolation (gnss powr-down mode)  0x1 = disable isolation (gnss active mode)" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "GNSS_RSTN                       ,gnss software reset  0x0 = gnss is in reset state  0x1 = gnss is released from reset" "0,1"
        bitfld.long 0x00 0. "         GNSS_HW_MODE1153                 ,hardware control mode for gnss power up and down" "0,1"
        bitfld.long 0x00 0. "   GNSS_HW_MODE1154                     ,hardware control mode for gnss power up and down" "0,1"

group d:0xD4282900++0x03
    line.long 0x00 "PMU_CC2_AP,AP Clock Control Register2"
        bitfld.long 0x00 29. " MPSUB_DBG_RST                   ,<var processor: application mp> debug reset  this field is used to reset the <var processor: application mp> debug/coresight logic, including <var processor: application> core dbg logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 28. "         C1_MPSUB_SW_RST                  ,<var processor: application mp> reset  this field is used to reset the <var processor: application mp> logic except debug/coresight logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 26. "   CPU7_SW_RST                          , cpu7 core software reset  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 25. "   CPU7_POR_RST                     , cpu7 core power on reset  this field is used to reset cpu7 all logic, including debug logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        textline "                                      "
        bitfld.long 0x00 23. "CPU6_SW_RST                     , cpu6 core software reset  this field is used to reset cpu6 core logic only.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 22. "         CPU6_POR_RST                     ,cpu6 core power on reset  this field is used to reset cpu6 all logic, including debug logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 20. "   CPU5_SW_RST                          ,cpu5 core software reset  this field is used to reset cpu5 core logic only.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 19. "   CPU5_POR_RST                     ,cpu5 core power on reset  this field is used to reset cpu5 all logic, including debug logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        textline "                                      "
        bitfld.long 0x00 17. "CPU4_SW_RST                     ,cpu4 core software reset  this field is used to reset cpu4 core logic only.  1 = core software reset is asserted  0 = core software reset is de-asserted" "0,1"
        bitfld.long 0x00 16. "         CPU4_POR_RST                     ,cpu4 core power on reset  this field is used to reset cpu4 all logic including debug logic.  1 = core power on reset is asserted  0 = core power on reset is de-asserted" "0,1"
        bitfld.long 0x00 12. "   C0_MPSUB_SW_RST                      ,<var processor: application mp> reset  this field is used to reset the <var processor: application mp> logic except debug/coresight logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 10. "   CPU3_SW_RST                      , cpu3 core software reset  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        textline "                                      "
        bitfld.long 0x00 9. "CPU3_POR_RST                    , cpu3 core power on reset  this field is used to reset cpu3 all logic, including debug logic.  1 = reset is asserted  0 = reset is de-asserted." "0,1"
        bitfld.long 0x00 7. "         CPU2_SW_RST                      , cpu2 core software reset  this field is used to reset cpu2 core logic only.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 6. "   CPU2_POR_RST                         ,cpu2 core power on reset  this field is used to reset cpu2 all logic, including debug logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 4. "   CPU1_SW_RST                      ,cpu1 core software reset  this field is used to reset cpu1 core logic only.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "CPU1_POR_RST                    ,cpu1 core power on reset  this field is used to reset cpu1 all logic, including debug logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 1. "         CPU0_SW_RST                      ,cpu0 core software reset  this field is used to reset cpu0 core logic only.  1 = core software reset is asserted  0 = core software reset is de-asserted" "0,1"
        bitfld.long 0x00 0. "   CPU0_POR_RST                         ,cpu0 core power on reset  this field is used to reset cpu0 all logic including debug logic.  1 = core power on reset is asserted  0 = core power on reset is de-asserted" "0,1"

group d:0xD4282904++0x03
    line.long 0x00 "PMUA_EM_CLK_RES_CTRL,EMMC5.0 Clock/Reset Control Register"
        bitfld.long 0x00 31. " EM_PHY_TMS_SW                   ,em5.0 ephy pad bypass/test mode sw enable   1 = bypass/test mode enable  0 = bypass/test disabled" "0,1"
        bitfld.long 0x00 30. "         EM_PHY_TOE_SW                    ,test data output select   1 = tdo ports are sampled with fclk (low speed only).   0 = tdo ports are directly from receiver" "0,1"
        bitfld.long 0x00 29. "   EM_PHY_VREF                          ,sw control the ephy vref port value" "0,1"
        bitfld.long 0x00 28. "   EM_PHY_V18EN                     ,ephy io 1.8 enable sw control   1 = 1.8v enable   0 = 1.8v disable" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "EM_PHY_LP_SEL                   ,ephy low power mode sw control   1 = lp mode enable   0 = lp mode disable" "0,1"
        bitfld.long 0x00 15. "         EM_1248M_CLK_EN                  ,em5.0 1248 mhz input clock enable  0 = disable em 1248m clock divider clock source  1 = enable em 1248m clock divider clock source" "0,1"
        bitfld.long 0x00 12.--14. "   EM_1248M_CLK_DIV                     ,emmc5.0 1248 mhz input clock frequency divisor  0x0 to 0x7 =  em_1248m_div5 = 1248 m source clock/(em_1248_clk_div + 1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 11. "   EM_CLK_FC_REQ                    ,when write this bit to 1 will force em_clk_div work, this bit will automatically cleared by hardware when clock switch is done" "0,1"
        textline "                                      "
        bitfld.long 0x00 8.--10. "EM_CLK_DIV                      ,em_clk_div  0-7 = em_clk = em source clock/(em_clk_div + 1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 6.--7. "         EM_CLK_SEL                       ,em clock source select  0 = 416mhz(clk_in_416m_pll1)  1 = 624 mhz(clk_in_pll1_2x)   2=48mhz clock  3=800mhz(clk_in_pll2)" "0,1,2,3"
        bitfld.long 0x00 4. "   EM_CLK_EN                            ,em peripheral clock enable  1 = peripheral clock enabled  0 = peripheral clock disabled" "0,1"
        bitfld.long 0x00 3. "   EM_AXICLK_EN                     ,em axi clock enable  1 = axi clock enabled  0 = axi clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "EM_RST                          ,em peripheral reset  0 = reset, actually emmc5.0 controller will only use em_axi_rst." "0,1"
        bitfld.long 0x00 0. "         EM_AXI_RST                       ,em axi reset." "0,1"

group d:0xD4282908++0x03
    line.long 0x00 "TRACE_CONFIG,Trace Clock Control Register"
        bitfld.long 0x00 19.--21. " PCLKDBG_DIV                     ,clock divider selection for pclkdbg. pclkdbg = atclk / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 17.--18. "         DBG_CLK_SEL                      ,internal trace clock source select  0x0 = 624 mhz  0x1 = 416 mhz  0x2 = 499mhz  0x3 = 832mhz clock  note that the debug clock is generated based on atclk." "0,1,2,3"
        bitfld.long 0x00 16. "   SWRST                                ,software reset  this field is used to reset all debug logic, low assert" "0,1"
        bitfld.long 0x00 15. "   TRACE_CLK_FC_REQ                 ,trace clock frequency change request  1 = trace_clk_div forced to work  this field is automatically cleared by hardware when clock switch is done" "0,1"
        textline "                                      "
        bitfld.long 0x00 11. "TPIU_CLK_SEL                    ,tpiu clock selection  select tpiu use internal clock or external input clock from pad, default will use the clock from internal" "0,1"
        bitfld.long 0x00 8.--10. "         TRACE_CLK_DIV                    ,trace clock frequency divisor  0-7 =trace_clk = trace source clock/(trace_clk_div + 1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 6.--7. "   TRACE_CLK_SEL                        ,internal trace clock source select  0x0 = 624 mhz  0x1 = 416 mhz  0x2 = 499mhz  0x3 = 832mhz clock" "0,1,2,3"
        bitfld.long 0x00 5. "   DBG_CLK_FC_REQ                   ,debug clock frequency change request  1 = force dbg_clk_div to operate  this field is automatically cleared by hardware when clock switch is done" "0,1"
        textline "                                      "
        bitfld.long 0x00 4. "TRACE_CLK_EN                    ,trace clock enable  enable the internal trace clock for tpiu trace output" "0,1"
        bitfld.long 0x00 3. "         DBGCLK_EN                        ,debug clock enable (including atclk and pclkdbg)  0 = debug clock disabled  1 = debug clock enabled" "0,1"
        bitfld.long 0x00 0.--2. "   ATCLK_DIV                            ,clock divider selection for atclk  atclk = (debug clock selection in trace_config[18:17]) / (this field +1)" "0,1,2,3,4,5,6,7"

group d:0xD4282910++0x03
    line.long 0x00 "PMUA_USB_PHY_CTRL0,USB PHY Control Register0"
        bitfld.long 0x00 18.--21. " USB_PHY_PLLPTUNE                ,usb phy pllptune" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--17. "        USB_PHY_PLLITUNE                 ,usb phy pllitune" "0,1,2,3"
        bitfld.long 0x00 11. "   USB_PHY_DCDENB                       ,usb phy dcdenb" "0,1"
        bitfld.long 0x00 10. "   USB_PHY_VDATSRCENB               ,usb phy vdatsrcenb" "0,1"
        textline "                                      "
        bitfld.long 0x00 9. "USB_PHY_VDATDETENB              ,usb phy vdatdetenb" "0,1"
        bitfld.long 0x00 8. "         USB_PHY_CHGSEL                   ,usb phy chgsel" "0,1"
        bitfld.long 0x00 7. "   USB_PHY_TXBITSTUFFENH                ,usb phy txbitstuffenh" "0,1"
        bitfld.long 0x00 6. "   USB_PHY_TXBITSTUFFEN             ,usb phy txbitstuffen" "0,1"
        textline "                                      "
        bitfld.long 0x00 5. "USB_PHY_SIDDQ                   ,usb phy siddq  1 = siddq mode<0> = not siddq mode" "0,1"
        bitfld.long 0x00 4. "         USB_PHY_SLEEPM                   ,usb phy sleepm  0 = sleep<1> = not sleep" "0,1"
        bitfld.long 0x00 3. "   USB_PHY_OTGDIS                       ,usb phy otg disable" "0,1"
        bitfld.long 0x00 2. "   USB_PHY_COMMONONN                ,usb phy commononn" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "USB_PHY_PORTRST                 ,usb phy port reset  1 = reset<0> = not reset" "0,1"
        bitfld.long 0x00 0. "         USB_PHY_POR                      ,usb phy power reset  1 = reset<0> = not reset" "0,1"

group d:0xD4282914++0x03
    line.long 0x00 "PMUA_USB_PHY_CTRL1,USB PHY Control Register1"
        bitfld.long 0x00 27. " USB_PHY_TXPREEMPPULSETUNE       ,usb phy txpreemppulsetune" "0,1"
        bitfld.long 0x00 25.--26. "         USB_PHY_TXPREEMPAMPTUNE          ,usb phy txpreempamptune0" "0,1,2,3"
        bitfld.long 0x00 23.--24. "   USB_PHY_TXRESTUNE                    ,usb phy txrestune" "0,1,2,3"
        bitfld.long 0x00 21.--22. "   USB_PHY_TXRISETUNE               ,usb phy txrisetune" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 17.--20. "USB_PHY_TXVREFTUNE              ,usb phy txvreftune" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 13.--16. "        USB_PHY_TXFSLSTUNE               ,usb phy txfslstune" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 11.--12. "  USB_PHY_TXHSXVTUNE                   ,usb phy txhsxvtune" "0,1,2,3"
        bitfld.long 0x00 8.--10. "   USB_PHY_OTGTUNE                  ,usb phy otgtune" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 6.--7. "USB_PHY_VDATREFTUNE             ,usb phy vdatreftune" "0,1,2,3"
        bitfld.long 0x00 3.--5. "         USB_PHY_SQRXTUNE                 ,usb phy sqrxtune" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0.--2. "   USB_PHY_COMPDISTUNE                  ,usb phy compdistune" "0,1,2,3,4,5,6,7"

group d:0xD428291C++0x03
    line.long 0x00 "PMUA_USB_PHY_TEST,USB PHY Test Register"
        hexmask.long.byte 0x00 24.--31. 1. " USB_PHY_TESTDATAIN              ,usb phy testdatain"
        bitfld.long 0x00 20.--23. "        USB_PHY_TESTADDR                 ,usb phy testaddr" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 19. "  USB_PHY_TESTBURNIN                   ,usb phy testburnin" "0,1"
        bitfld.long 0x00 18. "   USB_PHY_TESTDATAOUTSEL           ,usb phy testdataoutsel" "0,1"
        textline "                                      "
        bitfld.long 0x00 17. "USB_PHY_TESTEN                  ,usb phy testen" "0,1"
        bitfld.long 0x00 16. "         USB_PHY_TESTCLK                  ,usb phy testclk" "0,1"
        hexmask.long.byte 0x00 8.--15. 1. "   USB_PHY_SCANPSI                      ,usb phy scanpsi"
        bitfld.long 0x00 6. "  USB_PHY_LOOPBACKENB              ,usb phy loopbackenb" "0,1"
        textline "                                      "
        bitfld.long 0x00 5. "USB_PHY_SCANNSI                 ,usb phy scannsi" "0,1"
        bitfld.long 0x00 4. "         USB_PHY_SCANEN                   ,usb phy scanen" "0,1"
        bitfld.long 0x00 3. "   USB_PHY_SCANCLK                      ,usb phy scanclk" "0,1"
        bitfld.long 0x00 1.--2. "   USB_PHY_VATESTENB                ,usb phy vatestenb" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 0. "USB_PHY_ATERESET                ,usb phy atereset" "0,1"

group d:0xD4282924++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG0,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282928++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG1,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282960++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG2,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282964++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG3,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282B04++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG4,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282B08++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG5,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282B0C++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG6,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282B10++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG7,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282B40++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG8,<var Processor: Application> Core x  Idle Configuration Register"

group d:0xD4282B44++0x03
    line.long 0x00 "PMU_CAP_COREx_IDLE_CFG9,<var Processor: Application> Core x  Idle Configuration Register"
        bitfld.long 0x00 20.--21. " PM_PSW_MODE1300                 ,power switch mode  <var processor: application> core has both big macro power switch and distributed power switch. this field selects different power switch mode.  0x0 = both big macro switches and distributed switches used. during power up – first powe" "0,1,2,3"
        bitfld.long 0x00 19. "         PM_DIS_CORE_L1_SLP1301           ,disable l1 slp  this field is used to disable the core l1 sram power switch sleep power down during core power down mode.  1 = disable core l1 power switch sleep" "0,1"
        bitfld.long 0x00 18. "   PM_DIS_CORE_SLP1302                  ,disable core slp  this field is used to disable the core power switch sleep power down during core power down mode.  1 = disable core power switch sleep" "0,1"
        bitfld.long 0x00 11. "   MASK_CLK_OFF_CHECK1304           ,mask core clock off check during core idle process." "0,1"
        textline "                                      "
        bitfld.long 0x00 10. "MASK_CLK_STBL_CHECK1305         ,mask core clock stable check during core wakeup." "0,1"
        bitfld.long 0x00 9. "         MASK_JTAG_IDLE_CHECK1306         ,mask the jtag idle check during mp idle entry  1 = mask the jtag idle check." "0,1"
        bitfld.long 0x00 8. "   PM_MASK_CORE_WFI_IDLE_CHECK1307      ,debug only - it should be 0 during normal operation mask core wfi idle check  1 = status check masked  0 = status check not masked" "0,1"
        bitfld.long 0x00 4. "   MASK_GIC_NFIQ_TO_CORE            ,mask nfiq generated in gic for <var processor: application> core. software can set this bit before core enter c2. apmu hardware will automatically clear this bit when core enter c2" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "MASK_GIC_NIRQ_TO_CORE           ,mask nirq generated in gic for <var processor: application> core. software can set this bit before core enter c2. apmu hardware will automatically clear this bit when core enter c2" "0,1"
        bitfld.long 0x00 2. "         PM_CORE_L1_SRAM_PWRDWN1311       ,not used. l1 does not support retention" "0,1"
        bitfld.long 0x00 1. "   PM_CORE_PWRDWN1312                   ,core power down. this bit does not takes effect if core_idle is 0.  1 = when core issue wfi idle, core will go into deep sleep mode and power will be turned off. this bit will not take effect if <var processor: application> dbgnopwrdwn is set" "0,1"
        bitfld.long 0x00 0. "   PM_CORE_IDLE1313                 ,core idle  1 = when core issue wfi idle, the core clock will be gated externally. this bit will not take effect if <var processor: application> dbgnopwrdwn is set" "0,1"

group d:0xD428292C++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP0,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282930++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP1,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282934++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP2,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282938++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP3,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282B24++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP4,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282B28++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP5,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282B2C++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP6,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282B30++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP7,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282B60++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP8,<var Processor: Application> Core x Wakeup Register"

group d:0xD4282B64++0x03
    line.long 0x00 "PMU_CAP_COREx_WAKEUP9,<var Processor: Application> Core x Wakeup Register"
        bitfld.long 0x00 9. " WAKEUP_CORE9                    ,wakeup core9  if software writes 1 to this field, core 9 is woken up. writes of 0 to this bit and writes to this bit if core 9 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        bitfld.long 0x00 8. "         WAKEUP_CORE8                     ,wakeup core8  if software writes 1 to this field, core 8 is woken up. writes of 0 to this bit and writes to this bit if core 8 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        bitfld.long 0x00 7. "   WAKEUP_CORE7                         ,wakeup core7  if software writes 1 to this field, core 7 is woken up. writes of 0 to this bit and writes to this bit if core 7 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        bitfld.long 0x00 6. "   WAKEUP_CORE6                     ,wakeup core6  if software writes 1 to this field, core 6 is woken up. writes of 0 to this bit and writes to this bit if core 6 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        textline "                                      "
        bitfld.long 0x00 5. "WAKEUP_CORE5                    ,wakeup core5  if software writes 1 to this field, core 5 is woken up. writes of 0 to this bit and writes to this bit if core 5 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        bitfld.long 0x00 4. "         WAKEUP_CORE4                     ,wakeup core 4  if software writes 1 to this field, core 4 is woken up. writes of 0 to this bit and writes to this bit if core 4 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        bitfld.long 0x00 3. "   WAKEUP_CORE3                         ,wakeup core3  if software writes 1 to this field, core 3 is woken up. writes of 0 to this bit and writes to this bit if core 3 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        bitfld.long 0x00 2. "   WAKEUP_CORE2                     ,wakeup core2  if software writes 1 to this field, core 2 is woken up. writes of 0 to this bit and writes to this bit if core 2 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "WAKEUP_CORE1                    ,wakeup core1  if software writes 1 to this field, core 1 is woken up. writes of 0 to this bit and writes to this bit if core 1 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"
        bitfld.long 0x00 0. "         WAKEUP_CORE0                     ,wakeup core 0  if software writes 1 to this field, core 0 is woken up. writes of 0 to this bit and writes to this bit if core 0 is in c0 mode are ignored. this bit is cleared by pmu hardware when core3 exits c1/c2 mode." "0,1"

group d:0xD4282940++0x03
    line.long 0x00 "PMU_DVC_DFC_DEBUG,PMU DVC and DFC Debug Register"
        bitfld.long 0x00 5. " GLB_INT_MASK_USE_OLD_LOGIC      ,ap global interrupt mask use old logic   0x1=use old logic" "0,1"
        bitfld.long 0x00 4. "         AP_HW_DVC_EN_FOR_FAST_WAKEUP     ,enable hw-dvc or not if  ap interrupt is already pending before ap low power entry  0x0 = ap low power mode will not trigger hw-dvc if  ap interrupt is already pending before ap low power entry   0x1 = ap low power mode will trigger hw-dvc even if  ap interrupt is already pending before ap low power entry" "0,1"
        bitfld.long 0x00 3. "   APSUB_DFC_CHECK_MASK                 ,dfc check mask in ap subsystem pmu state machine  0 = dfc status check enabled  1 = dfc status check masked" "0,1"
        bitfld.long 0x00 2. "   APSUB_DVC_CHECK_MASK             ,dvc check mask in ap subsystem pmu state machine  0 = dfc status check enabled  1 = dfc status check masked" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "CP_DVC_CHECK_MASK               ,dvc check mask in cp pmu state machine    0 = dfc status check enabled  1 = dfc status check masked" "0,1"
        bitfld.long 0x00 0. "         MP_DVC_CHECK_MASK                ,dvc check mask in dragon mp subsystem pmu state machine  0 = dfc status check enabled  1 = dfc status check masked" "0,1"

group d:0xD4282948++0x03
    line.long 0x00 "PMU_VSP_CLK_RES_CTRL,VSP Clock/Reset Control Register"
        bitfld.long 0x00 27. " VSP_HW_MODE                     ,vsp hardware on/off control mode  1 = hardware controls isp on/off procedure" "0,1"
        bitfld.long 0x00 26. "         VSP_SLEEP2                       ,vsp power switch sleep2" "0,1"
        bitfld.long 0x00 25. "   VSP_SLEEP1                           ,vsp power switch sleep1" "0,1"
        bitfld.long 0x00 24. "   VSP_ISOB                         ,vsp isolation cell enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 22.--23. "XM4_OCEM_DIV                    ,xm4 ocem clock divide ratio" "0,1,2,3"
        bitfld.long 0x00 20.--21. "         XM4_IOP_DIV                      ,xm4 iop clock divide ratio" "0,1,2,3"
        bitfld.long 0x00 18.--19. "   XM4_EDAP_DIV                         ,xm4 edap clock divide ratio" "0,1,2,3"
        bitfld.long 0x00 17. "   AFBC_DEC_CLK_EN                  ,afbc decoder function clock enable  1 = clock enabled  0 = clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 16. "AFBC_ENC_CLK_EN                 ,afbc encoder function clock enable  1 = clock enabled  0 = clock disabled" "0,1"
        bitfld.long 0x00 15. "         VSP_CLK_FC_REQ                   ,vsp function clk fc request  1 = triggers a frequency change  this field is hardware cleared when the frequency change is done." "0,1"
        bitfld.long 0x00 14. "   XM4_OCEM_RSTN                        ,xm4 ocem clock reset  0 = reset" "0,1"
        bitfld.long 0x00 13. "   XM4_GLB_RSTN                     ,xm4 global clock reset  0 = reset" "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "XM4_SYS_RSTN                    ,xm4 system clock reset  0 = reset" "0,1"
        bitfld.long 0x00 11. "         XM4_CORE_RSTN                    ,xm4 core clock reset  0 = reset" "0,1"
        bitfld.long 0x00 10. "   VSP_CLK_RSTN                         ,vsp function clock reset  0 = reset" "0,1"
        bitfld.long 0x00 8. "   VSP_CLK_EN                       ,vsp function clock enable  1 = clock enabled  0 = clock disabled" "0,1"
        textline "                                      "
        bitfld.long 0x00 3.--5. "VSP_CLK_SEL                     ,isp function clock source select  0x0 = 624mhz  0x1 = 499 mhz  0x2 = 832mhz  0x3 = pll3_div2  0x4 = pll3_div3  0x5 = pll3_div4  0x6 = pll2_div4  0x7 = pll4_div3" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0.--2. "         VSP_CLK_DIV                      ,vsp function clock divide ratio  vsp_clk = vsp_clk_div / (this field +1)" "0,1,2,3,4,5,6,7"

group d:0xD428294C++0x03
    line.long 0x00 "PMU_AUDIO_CLK_RES_CTRL,Audio Clock Reset Enable Register"
        bitfld.long 0x00 31. " AUDIO_SD_STATUS                 ,audio sd domain status  1 audio pmu is  in power on status ;   0=audio pmu is power off status" "0,1"
        bitfld.long 0x00 30. "         AUDIO_FUSE_LOAD_START            ,audio fuse load start. note that when audio fuse loading finishes, this field is automatically cleared by hardware logic.  0x0 = don't trigger audio fuse loading or fuse loading has finished  0x1 = trigger audio fuse loading" "0,1"
        bitfld.long 0x00 29. "   AUDIO_FUSE_LOAD_MASK                 ,audio fuse load mask, only used when audio uses hw power mode  0x0 = no mask  0x1 = mask fuse load operation." "0,1"
        bitfld.long 0x00 28. "   AP_POWER_CTL_AUDIO_AUTHO         ,ap power control audio authority  0=ap  can control audio power now  1: ap can't control audio power" "0,1"
        textline "                                      "
        bitfld.long 0x00 27. "AUDIO_HW_MODE                   ,hardware control mode for audio power up and down" "0,1"
        bitfld.long 0x00 26. "         AUDIO_SLEEP2                     ,audio power switch sleep2" "0,1"
        bitfld.long 0x00 25. "   AUDIO_SLEEP1                         ,audio power switch sleep1" "0,1"
        bitfld.long 0x00 24. "   AUDIO_ISOB                       ,audio isolation control  0x0 = enable isolation (audio powr-down mode)  0x1 = disable isolation (audio active mode)" "0,1"
        textline "                                      "
        bitfld.long 0x00 23. "AUDIO_PWR_STATUS                ,power status for audio island   1  = audio island is power off   0 = audio island is power on" "0,1"
        bitfld.long 0x00 20.--22. "         AUDIO_APB_DIV                    ,clock divider for apb clock in audio island apb_clk =aud_clk/(audio_apb_div+1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 16.--17. "   AUDIO_AXI_DIV                        ,clock divider for apb clock in audio island axi_clk = aud_clk/(audio_axi_div+1)" "0,1,2,3"
        bitfld.long 0x00 15. "   AUDIO_FC_REQ                     ,audio island main clock fc request  1 = triggers a frequency change  this field is hardware cleared when the frequency change is done." "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "AUDIO_CLK_EN                    ,audio clcok enable  1 = enable" "0,1"
        bitfld.long 0x00 10. "         AUDIO_HW_CKG_BYPASS              ,audio always on domain reset, this bit should be always set to 1 after the silicon power up" "0,1"
        bitfld.long 0x00 7.--9. "   AUDIO_CLK_SEL                        ,clock sel control for audio main clock   0= pll 312m   1= pll 416m   2= pll 499m   3 = pll7_div2   4 = pll7_div3   5 = pll7_div4   6 = pll7_div5" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 4.--6. "   AUDIO_CLK_DIV                    ,clock divider control for audio main clock audio main clk = selected clk/(audio_clk_div+1)" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 3. "AUDIO_APMU_RESET                ,audio apmu reset, this bit should be always set to 1 after the silicon power up" "0,1"
        bitfld.long 0x00 2. "         TL421_EXT_CORE_RESET             ,tl421 ext_core_rst    0 = reset   1 = release reset" "0,1"
        bitfld.long 0x00 1. "   TL421_ORESET                         ,tl421 orst    0 = reset   1 = release reset" "0,1"
        bitfld.long 0x00 0. "   AUDIO_SYS_RESET                  ,audio island system reset   0 = reset   1 = release reset" "0,1"

group d:0xD4282980++0x03
    line.long 0x00 "DFC_AP,<var Processor: Application MP> DCLK Dynamic Freq Change Control Register"
        bitfld.long 0x00 1.--3. " PM_FL1417                       ,dclk freq level in active mode  required freq level by <var processor: application mp> in active mode" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0. "         PM_DFC_REQ1418                   ,dclk hfc request in active mode  dclk hfc request for <var processor: application mp> in active mode  software can write 1 to this bit to trigger a dclk hfc request. hardware will automatically clear this bit when hfc is done. writes of 0 to this bit are ignored." "0,1"

group d:0xD4282988++0x03
    line.long 0x00 "DFC_STATUS,DCLK Hardware Freq Change Status Register"
        bitfld.long 0x00 7.--10. " PM_DFC_CAUSE1426                ,dclk dfc cause  this field is the cause of the current ongoing dfc. it is only valid when the <dclk_dfc_status> field is 1.  0x1 = <var processor: application mp> triggered dfc  0x2 = <var processor: comm> triggered dfc in active mode  0x4 = msa trigged dfc in active mode    0x8 = gnss triggered dfc in active mode    others = low power mode entry/exit triggered dfc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--6. "        PM_TFL1427                       ,target freq level of dclk" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 1.--3. "   PM_CFL1428                           ,current freq level of dclk" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0. "   PM_DFC_STATUS1429                ,dclk dfc status  the dclk dfc may be triggered in active state or <var processor: comm>/msa entering low power mode.  0 = there is no dfc or dfc has finished  1 = dfc is in progress" "0,1"

group d:0xD4282990++0x03
    line.long 0x00 "DFC_LEVEL0,DCLK Freq Level 0 Control Register"
        bitfld.long 0x00 16.--19. " VL1437                          ,required voltage level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7.--11. "        MC_TABLE_NUM1439                 ,memory controller table number  valid values are from 0x1 to 0xe. this is used for table-based ddr clock freq change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 4.--6. "  DDR_CLK_DIV1440                      ,clock divider selection for dclk  dclk = <dclk_clock_selection> / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   4X_CLK_MODE1441                  ,enable 4:1 dclk mode  0x0 = 2:1 dclk mode  0x1 = 4:1 dclk mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 0.--2. "DCLKSEL1442                     ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6 div1                          0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD4282994++0x03
    line.long 0x00 "DFC_LEVEL1,DCLK Freq Level 1 Control Register"
        bitfld.long 0x00 16.--19. " VL1450                          ,required voltage level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7.--11. "        MC_TABLE_NUM1452                 ,memory controller table number  valid values are from 0x1 to 0xe. this is used for table-based ddr clock freq change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 4.--6. "  DDR_CLK_DIV1453                      ,clock divider selection for dclk  dclk = <dclk_clock_selection> / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   4X_CLK_MODE1454                  ,enable 4:1 dclk mode  0x0 = 2:1 dclk mode  0x1 = 4:1 dclk mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 0.--2. "DCLKSEL1455                     ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6 div1                          0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD4282998++0x03
    line.long 0x00 "DFC_LEVEL2,DCLK Freq Level 2 Control Register"
        bitfld.long 0x00 16.--19. " VL1463                          ,required voltage level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7.--11. "        MC_TABLE_NUM1465                 ,memory controller table number  valid values are from 0x1 to 0xe. this is used for table-based ddr clock freq change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 4.--6. "  DDR_CLK_DIV1466                      ,clock divider selection for dclk  dclk = <dclk_clock_selection> / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   4X_CLK_MODE1467                  ,enable 4:1 dclk mode  0x0 = 2:1 dclk mode  0x1 = 4:1 dclk mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 0.--2. "DCLKSEL1468                     ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6 div1                          0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD428299C++0x03
    line.long 0x00 "DFC_LEVEL3,DCLK Freq Level 3 Control Register"
        bitfld.long 0x00 16.--19. " VL1476                          ,required voltage level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7.--11. "        MC_TABLE_NUM1478                 ,memory controller table number  valid values are from 0x1 to 0xe. this is used for table-based ddr clock freq change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 4.--6. "  DDR_CLK_DIV1479                      ,clock divider selection for dclk  dclk = <dclk_clock_selection> / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   4X_CLK_MODE1480                  ,enable 4:1 dclk mode  0x0 = 2:1 dclk mode  0x1 = 4:1 dclk mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 0.--2. "DCLKSEL1481                     ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6 div1                          0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD42829A0++0x03
    line.long 0x00 "DFC_LEVEL4,DCLK Freq Level 4 Control Register"
        bitfld.long 0x00 16.--19. " VL1489                          ,required voltage level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7.--11. "        MC_TABLE_NUM1491                 ,memory controller table number  valid values are from 0x1 to 0xe. this is used for table-based ddr clock freq change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 4.--6. "  DDR_CLK_DIV1492                      ,ddr clock selection  0x7 = pll3 div2   0x6 = pll5 div2   0x4 = pll2 div2   0x5 = pll4 div2   0x0 = pll1 624 mhz  0x1 = pll1 832 mhz" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   4X_CLK_MODE1493                  ,enable 4:1 dclk mode  0x0 = 2:1 dclk mode  0x1 = 4:1 dclk mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 0.--2. "DCLKSEL1494                     ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6 div1                          0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD42829A4++0x03
    line.long 0x00 "DFC_LEVEL5,DCLK Freq Level 5 Control Register"
        bitfld.long 0x00 16.--19. " VL1502                          ,required voltage level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7.--11. "        MC_TABLE_NUM1504                 ,memory controller table number  valid values are from 0x1 to 0xe. this is used for table-based ddr clock freq change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 4.--6. "  DDR_CLK_DIV1505                      ,clock divider selection for dclk  dclk = <dclk_clock_selection> / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   4X_CLK_MODE1506                  ,enable 4:1 dclk mode  0x0 = 2:1 dclk mode  0x1 = 4:1 dclk mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 0.--2. "DCLKSEL1507                     ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6 div1                          0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD42829A8++0x03
    line.long 0x00 "DFC_LEVEL6,DCLK Freq Level 6 Control Register"
        bitfld.long 0x00 16.--19. " VL1515                          ,required voltage level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7.--11. "        MC_TABLE_NUM1517                 ,memory controller table number  valid values are from 0x1 to 0xe. this is used for table-based ddr clock freq change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 4.--6. "  DDR_CLK_DIV1518                      ,clock divider selection for dclk  dclk = <dclk_clock_selection> / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   4X_CLK_MODE1519                  ,enable 4:1 dclk mode  0x0 = 2:1 dclk mode  0x1 = 4:1 dclk mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 0.--2. "DCLKSEL1520                     ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6 div1                          0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD42829AC++0x03
    line.long 0x00 "DFC_LEVEL7,DCLK Freq Level 7 Control Register"
        bitfld.long 0x00 16.--19. " VL1528                          ,required voltage level" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7.--11. "        MC_TABLE_NUM1530                 ,memory controller table number  valid values are from 0x1 to 0xe. this is used for table-based ddr clock freq change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 4.--6. "  DDR_CLK_DIV1531                      ,clock divider selection for dclk  dclk = <dclk_clock_selection> / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   4X_CLK_MODE1532                  ,enable 4:1 dclk mode  0x0 = 2:1 dclk mode  0x1 = 4:1 dclk mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 0.--2. "DCLKSEL1533                     ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6 div1                          0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD42829B0++0x03
    line.long 0x00 "PMU_DEBUG2_REG,PMU Debug2 Register"
        hexmask.long.word 0x00 16.--31. 1. " GNSS_VOTING_MASK                ,gnss voting mask  0x0 = no mask  0x1 = mask"
        bitfld.long 0x00 12.--13. "      CSYSFREQUENCY_DDRC               ,fp to ddrc lp/ffc protocol signal" "0,1,2,3"
        bitfld.long 0x00 11. "   CSYSACK_DDRC_CH1                     ,ack from ddrc ch1 lp/ffc protocol signal" "0,1"
        bitfld.long 0x00 10. "   CSYSACK_DDRC                     ,ack from ddrc ch0 lp/ffc protocol signal" "0,1"
        textline "                                      "
        bitfld.long 0x00 9. "CSYSMODE_DDRC                   ,csysmode to ddrc lp/ffc protocol signal" "0,1"
        bitfld.long 0x00 8. "         CSYSREQ_DDRC                     ,csysreq to ddrc lp/ffc protocol signal" "0,1"
        bitfld.long 0x00 2. "   DCLK_MSTR_GATE_OK_CHECK_ACLK         ,ap clkgen mask dclk_mstr_gate_ok check  1 = no check  0 = check" "0,1"
        bitfld.long 0x00 1. "   DCLK_MSTR_GATE_OK_CHECK_CP       ,ap clkgen mask dclk_mstr_gate_ok check  1 = no check  0 = check" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "DCLK_MSTR_GATE_OK_CHECK_AP      ,ap clkgen mask dclk_mstr_gate_ok check  1 = no check  0 = check" "0,1"

group d:0xD42829B8++0x03
    line.long 0x00 "GNSS_WAKEUP_CTRL,GNSS Wakeup Control Register"
        bitfld.long 0x00 2. " GNSS_WAKEUP_STATUS              ,gnss wakeup signal status  this field is used to sample the wakeup signal from the gnss module.  0x0 = wakeup signal inactive  0x1 = wakeup active" "0,1"
        bitfld.long 0x00 1. "         GNSS_WAKEUP_CLR                  ,gnss wakeup clear  the <var processor: application mp> acknowledges the wake-up event from gps.  it can only be asserted when the wake-up event from the gps is active. it is cleared by hardware when the gps get an acknowledge from the <var processor: ap" "0,1"
        bitfld.long 0x00 0. "   GNSS_WAKEUP_EN                       ,gnss wakeup enable  0x0 = disable gnss wakeup  0x1 = enable gnss wakeup chip" "0,1"

group d:0xD42829BC++0x03
    line.long 0x00 "PMU_CCIC2_CLK_GATE_CTRL,CMOS Camera Interface Controller 2 Dynamic Clock Gate Control Register"
        bitfld.long 0x00 30.--31. " CCIC2_GATE_CSI_CLK_STATIC       ,ccic2 csi static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 28.--29. "         CCIC2_GATE_CLK4X_STATIC          ,ccic2 clk4x static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 26.--27. "   CCIC2_GATE_CLK1X_STATIC              ,ccic2 clk1x static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 24.--25. "   CCIC2_GATE_HCLK_STATIC           ,ccic2 hclk static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 22.--23. "CCIC2_GATE_ACLK_STATIC          ,ccic2 aclk static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 20.--21. "         CCIC2_GATE_ISP_PIP2_CLK1X_STATIC ,isp pipe2 clk1x static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 18.--19. "   CCIC2_GATE_QOS_HCLK_STATIC           ,axi4to1qos hclk static clock gate contro  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 16.--17. "   CCIC2_GATE_DESC_HCLK_STATIC      ,sc2_desc_top hclk static clock gate control  0x0 =stop clock   0x1 = stop clock   0x2 = stop clock  0x3 = free running" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 10.--11. "CCIC2_GATE_LANE1_CLK_DYNAMIC    ,ccic2 csi lane 1 clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 8.--9. "         CCIC2_GATE_LANE0_CLK_DYNAMIC     ,ccic2 csi lane 0 clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 6.--7. "   CCIC2_GATE_CSI_CLK_DYNAMIC           ,ccic2 csi clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 4.--5. "   CCIC2_GATE_AHB_CLK_DYNAMIC       ,ccic2 ahb clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        textline "                                      "
        bitfld.long 0x00 2.--3. "CCIC2_GATE_PIP_CLK_DYNAMIC      ,ccic2 pipeline clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"
        bitfld.long 0x00 0.--1. "         CCIC2_GATE__AXI_CLK_DYNAMIC      ,ccic2 axi clock dynamic clock gate control  0x0 = hardware dynamic control  0x1 = hardware dynamic control  0x2 = stop clock  0x3 = free running" "0,1,2,3"

group d:0xD42829C0++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C0_CTRL,Generic Timer Wakeup Core0 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C0_STATUS             ,generic timer wakeup core0 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C0_ENB                 ,generic timer wakeup core0 enable, when core0 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD42829C4++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C1_CTRL,Generic Timer Wakeup Core1 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C1_STATUS             ,generic timer wakeup core1 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C1_ENB                 ,generic timer wakeup core1 enable, when core1 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD42829C8++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C2_CTRL,Generic Timer Wakeup Core2 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C2_STATUS             ,generic timer wakeup core2 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C2_ENB                 ,generic timer wakeup core2 enable, when core2 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD42829CC++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C3_CTRL,Generic Timer Wakeup Core3 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C3_STATUS             ,generic timer wakeup core3 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C3_ENB                 ,generic timer wakeup core3 enable, when core3 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD42829D0++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C0_ML,Generic Timer Wakeup Core0 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C0_ML                 ,generic timer wakeup core0 match low register"

group d:0xD42829D4++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C0_MH,Generic Timer Wakeup Core0 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C0_MH                 ,generic timer wakeup core0 match high register"

group d:0xD42829D8++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C1_ML,Generic Timer Wakeup Core1 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C1_ML                 ,generic timer wakeup core1 match low register"

group d:0xD42829DC++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C1_MH,Generic Timer Wakeup Core1 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C1_MH                 ,generic timer wakeup core1 match high register"

group d:0xD42829E0++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C2_ML,Generic Timer Wakeup Core2 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C2_ML                 ,generic timer wakeup core2 match low register"

group d:0xD42829E4++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C2_MH,Generic Timer Wakeup Core2 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C2_MH                 ,generic timer wakeup core2 match high register"

group d:0xD42829E8++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C3_ML,Generic Timer Wakeup Core3 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C3_ML                 ,generic timer wakeup core3 match low register"

group d:0xD42829EC++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C3_MH,Generic Timer Wakeup Core3 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C3_MH                 ,generic timer wakeup core3 match high register"

group d:0xD4282B34++0x03
    line.long 0x00 "FC_LOCK_STATUS,Frequency change Lock Status Register"
        bitfld.long 0x00 1. " CP_RD_STATUS1685                ,cp read status   0x0=cp does not get the fc lock.  0x1=cp get the fc lock ." "0,1"
        bitfld.long 0x00 0. "         AP_RD_STATUS1686                 ,ap read status   0x0=ap does not get the fc lock.  0x1=ap get the fc lock ." "0,1"

group d:0xD4282A08++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C4_CTRL,Generic Timer Wakeup Core4 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C4_STATUS             ,generic timer wakeup core4 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C4_ENB                 ,generic timer wakeup core4 enable, when core3 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD4282A0C++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C5_CTRL,Generic Timer Wakeup Core5 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C5_STATUS             ,generic timer wakeup core5 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C5_ENB                 ,generic timer wakeup core5 enable, when core3 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD4282A10++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C6_CTRL,Generic Timer Wakeup Core6 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C6_STATUS             ,generic timer wakeup core6 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C6_ENB                 ,generic timer wakeup core6 enable, when core3 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD4282A14++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C7_CTRL,Generic Timer Wakeup Core7 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C7_STATUS             ,generic timer wakeup core7 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C7_ENB                 ,generic timer wakeup core7 enable, when core3 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD4282A18++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C4_ML,Generic Timer Wakeup Core4 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C4_ML                 ,generic timer wakeup core4 match low register"

group d:0xD4282A1C++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C4_MH,Generic Timer Wakeup Core4 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C4_MH                 ,generic timer wakeup core4 match high register"

group d:0xD4282A20++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C5_ML,Generic Timer Wakeup Core5 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C5_ML                 ,generic timer wakeup core5 match low register"

group d:0xD4282A24++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C5_MH,Generic Timer Wakeup Core5 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C5_MH                 ,generic timer wakeup core5 match high register"

group d:0xD4282A28++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C6_ML,Generic Timer Wakeup Core6 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C6_ML                 ,generic timer wakeup core6 match low register"

group d:0xD4282A2C++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C6_MH,Generic Timer Wakeup Core6 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C6_MH                 ,generic timer wakeup core6 match high register"

group d:0xD4282A30++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C7_ML,Generic Timer Wakeup Core7 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C7_ML                 ,generic timer wakeup core7 match low register"

group d:0xD4282A34++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C7_MH,Generic Timer Wakeup Core7 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C7_MH                 ,generic timer wakeup core7 match high register"

group d:0xD4282A38++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C8_CTRL,Generic Timer Wakeup Core8 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C8_STATUS             ,generic timer wakeup core8 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C8_ENB                 ,generic timer wakeup core8 enable, when core3 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD4282A3C++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C9_CTRL,Generic Timer Wakeup Core9 Control Register"
        bitfld.long 0x00 8. " GT_WAKEUP_C9_STATUS             ,generic timer wakeup core9 status. read  0x0 = no wakeup interrupt occur  0x1 = wakeup interrrupt occur write  0x0 = clear wakeup interrupt status   0x1 = no effect" "0,1"
        bitfld.long 0x00 0. "         GT_WAKEUP_C9_ENB                 ,generic timer wakeup core9 enable, when core3 enter c2  0x0 = not enable  0x1 = enable" "0,1"

group d:0xD4282A48++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C8_ML,Generic Timer Wakeup Core8 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C8_ML                 ,generic timer wakeup core8 match low register"

group d:0xD4282A4C++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C8_MH,Generic Timer Wakeup Core8 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C8_MH                 ,generic timer wakeup core8 match high register"

group d:0xD4282A50++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C9_ML,Generic Timer Wakeup Core9 Match Low Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C9_ML                 ,generic timer wakeup core9 match low register"

group d:0xD4282A54++0x03
    line.long 0x00 "PMU_GT_WAKEUP_C9_MH,Generic Timer Wakeup Core9 Match High Register"
        hexmask.long 0x00 0.--31. 1. " GT_WAKEUP_C9_MH                 ,generic timer wakeup core9 match high register"

group d:0xD4282B14++0x03
    line.long 0x00 "PMU_C1_CAPMP_IDLE_CFGx0,Cluster1 <var Processor: Application MP> Idle Configuration Register for Core x"

group d:0xD4282B18++0x03
    line.long 0x00 "PMU_C1_CAPMP_IDLE_CFGx1,Cluster1 <var Processor: Application MP> Idle Configuration Register for Core x"

group d:0xD4282B1C++0x03
    line.long 0x00 "PMU_C1_CAPMP_IDLE_CFGx2,Cluster1 <var Processor: Application MP> Idle Configuration Register for Core x"

group d:0xD4282B20++0x03
    line.long 0x00 "PMU_C1_CAPMP_IDLE_CFGx3,Cluster1 <var Processor: Application MP> Idle Configuration Register for Core x"
        bitfld.long 0x00 19. " DIS_MP_L2_SLP1839               ,disable <var processor: application mp> l2 power switch  this field is used to disable the <var processor: application mp> l2 power switch sleep power down during <var processor: application mp> power down mode.  1 = disable <var processor: application" "0,1"
        bitfld.long 0x00 18. "         DIS_MP_SLP1840                   ,disable <var processor: application mp> power switch  this field is used to disable the <var processor: application mp> power switch sleep power down during mp subsystem power down mode.  1 = disable mp power switch sleep" "0,1"
        bitfld.long 0x00 16. "   MP_L2_PWR_OFF1842                    ,frc l2 sram off  1 = l2 cache power is off" "0,1"
        bitfld.long 0x00 13. "   L2_HW_CACHE_FLUSH_EN1844         ,l2 hardware cache flush enable  0x1= enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "MASK_SRAM_REPAIR_DONE_CHECK1845 ,mask sram repair done check  1 = mask sram repair done check" "0,1"
        bitfld.long 0x00 11. "         MASK_CLK_OFF_CHECK1846           ,mask <var processor: application mp> clock off state check  this field is used to mask the <var processor: application mp> clock off check during the mp idle process." "0,1"
        bitfld.long 0x00 10. "   MASK_CLK_STBL_CHECK1847              ,mask mp clock stbl state check  this field is used to mask the mp clock stable check during mp wakeup." "0,1"
        bitfld.long 0x00 9. "   MASK_JTAG_IDLE_CHECK1848         ,mask jtag idle state check  this field is used to mask the jtag idle check during <var processor: application mp> idle entry.  1 = mask jtag idle check" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "MASK_IDLE_CHECK1849             ,mask <var processor: application mp> idle state check  debug only - it should be 0 during normal operation  1 = status check masked  0 = status check not masked" "0,1"
        bitfld.long 0x00 7. "         ACINACTM_HW_CTRL1850             ,acinactm hardware control   0x0=low power state machine does not control acinactm port.   0x1= low power state machine will control acinactm port of <var processor: application mp>.  when m2/m1 low power mode is entered, acinactm port will be high" "0,1"
        bitfld.long 0x00 5. "   DIS_MC_SW_REQ1852                    ,disable memory controller software req  this field is used to disable the memory controller entry to idle mode using the memory controller sleep request bits. the memory controller will always enter into idle mode based upon the hardware state machine re" "0,1"
        bitfld.long 0x00 4. "   MP_WAKE_MC_EN1853                ,<var processor: application mp> wake mc enable  wake up the memory controller when the <var processor: application mp> wakes up from idle mode. the memory controller will be woken up before the interrupt to the core is released.  0 = memory controller w" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "MP_SCU_SRAM_PWRDWN1854          ,not used. scu sram does not support retention" "0,1"
        bitfld.long 0x00 3. "         PM_1855                          ,reserved for future use" "0,1"
        bitfld.long 0x00 2. "   L2_SRAM_PWRDWN1856                   ,l2 cache sram power down  this field does not take effect if mp_pwrdwn is 0.  1 = when <var processor: application mp> is idle, l2 sram power will be off  0 = when <var processor: application mp> is idle, l2 sram is in retention mode" "0,1"
        bitfld.long 0x00 1. "   MP_PWRDWN1857                    ,<var processor: application mp> power down  this field does not take effect if mp_idle is 0.  1 = when <var processor: application mp> is idle, <var processor: application mp> will go into deep sleep mode and <var processor: application mp> logic will b" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "MP_IDLE1858                     ,<var processor: application mp> idle  1 = when <var processor: application mp> is idle, <var processor: application mp> clocks will be gated externally" "0,1"

group d:0xD4282B00++0x03
    line.long 0x00 "PMU_CCI_CLK_CTRL,CCI550 Clock Control Register"
        hexmask.long.word 0x00 17.--31. 1. " PM_1865                         ,reserved"
        bitfld.long 0x00 16. "      MASK_DRAGON_ADB400_CCI_SIDE_IDLE ,mask dragon adb400 cci side idle flag for cci_idle_clk_off_req   1=mask   0=unmask" "0,1"
        bitfld.long 0x00 15. "   CCI_CLK_SMOOTH_MUX_DIS               ,cci clock smoothmux disable   0= cci clock smoothmux enable, it will hw switch to vcxo clock when cpu enters m2 and gpu shutdonw   1=cci clock smoothmux disable, it only selects the clock from cci_clock_gen, when  cpu enters m2 and gpu shutdonw, the cci clock is gated." "0,1"
        bitfld.long 0x00 14. "   CCI_CLKEN_BY_INT_AP              ,cci clock also can be enabled by sys_int_ap[127:0]  0x1=enable this function. if this bit is 0x0, then the cci clock is still only controlled by the status of cpu clusters and gpu" "0,1"
        textline "                                      "
        bitfld.long 0x00 13. "CCI550_CLKGEN_AUTO_CG_EN        ,cci550 clock generator working clock automatic gating control    0x0 = cci550 clock generator working clock automatic gating is disabled and the clock is free-runing    0x1 = cci550 clock generator working clock automatic gating is enabled" "0,1"
        bitfld.long 0x00 12. "         CCI550_FC_REQ                    ,cci550  freq change request. when frequency change is done, this bit is automaticlly cleared by hardware" "0,1"
        bitfld.long 0x00 11. "   PM_1871                              ,reserved" "0,1"
        bitfld.long 0x00 8.--10. "   CCI550_BIU_CLK_DIV               ,clock divider selection for cci550 axi_m0 port to fabric.  aclk_m0 = aclkm1/ (this field +1)" "0,1,2,3,4,5,6,7"
        textline "                                      "
        bitfld.long 0x00 7. "PM_1873                         ,reserved" "0,1"
        bitfld.long 0x00 4.--6. "         CCI550_MC_CLK_DIV                ,clock divider selection for cci550 axi_m1 port to mck. aclk_m1 = pll_source / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "   PM_1875                              ,reserved" "0,1"
        bitfld.long 0x00 0.--2. "   CCI550_PLLSEL                    ,<var processor: application> cci550 clock selection  0x0 = pll1_499mhz   0x1 = pll1 624mhz   0x2 = pll1_832 mhz   0x3 = pll3_div3（700m）   0x4=pll2_div4(600m)   0x5=pll3_div4(525m)   0x6=pll4_div3(335m)   0x7=pll3_div2(1050m)" "0,1,2,3,4,5,6,7"

group d:0xD4282B38++0x03
    line.long 0x00 "PMU_CC3_AP,AP Clock Control Register"
        bitfld.long 0x00 18. " C2_MPSUB_SW_RST                 ,<var processor: application mp> reset  this field is used to reset the <var processor: application mp> logic except debug/coresight logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 10. "         CPU9_SW_RST                      ,cpu9 core software reset  this field is used to reset cpu9 core logic only.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 9. "   CPU9_POR_RST                         ,cpu9 core power on reset  this field is used to reset cpu9 all logic, including debug logic.  1 = reset is asserted  0 = reset is de-asserted" "0,1"
        bitfld.long 0x00 7. "   CPU8_SW_RST                      ,cpu8 core software reset  this field is used to reset cpu8 core logic only.  1 = core software reset is asserted  0 = core software reset is de-asserted" "0,1"
        textline "                                      "
        bitfld.long 0x00 6. "CPU8_POR_RST                    ,cpu8 core power on reset  this field is used to reset cpu8 all logic including debug logic.  1 = core power on reset is asserted  0 = core power on reset is de-asserted" "0,1"
        bitfld.long 0x00 3.--5. "         C2_ACLK_DIV1891                  ,clock divider selection for cluster2 axi interface clock  c2_aclk is divided from pclk. c2_aclk= pclk / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0.--2. "   C2_CLK_DIV1892                       ,clock divider selection for cluster2 pclk. if (fcap.c2_pllsel<=3), pclk= (fcap.c2_pllsel selectin clock )/(c2_clk_div +1);  else pclk =fcap.c2_pllsel selectin clock" "0,1,2,3,4,5,6,7"

group d:0xD4282B3C++0x03
    line.long 0x00 "PMU_DM_CC2_AP,Dummy AP Clock Control2 Register"
        bitfld.long 0x00 3.--5. " C2_ACLK_DIV1900                 ,clock divider selection for cluster2 axi interface clock  c2_aclk is divided from pclk. c2_aclk= pclk / (this field +1)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0.--2. "         C2_CLK_DIV1901                   ,clock divider selection for cluster2 pclk. if (fcap.c2_pllsel<=3), pclk= (fcap.c2_pllsel selectin clock )/(c2_clk_div +1);  else pclk =fcap.c2_pllsel selectin clock" "0,1,2,3,4,5,6,7"

group d:0xD4282B50++0x03
    line.long 0x00 "PMU_C2_CAPMP_IDLE_CFGx0,Cluster2 <var Processor: Application MP> Idle Configuration Register for Core x"

group d:0xD4282B54++0x03
    line.long 0x00 "PMU_C2_CAPMP_IDLE_CFGx1,Cluster2 <var Processor: Application MP> Idle Configuration Register for Core x"
        bitfld.long 0x00 19. " DIS_MP_L2_SLP1910               ,disable <var processor: application mp> l2 power switch  this field is used to disable the <var processor: application mp> l2 power switch sleep power down during <var processor: application mp> power down mode.  1 = disable <var processor: application" "0,1"
        bitfld.long 0x00 18. "         DIS_MP_SLP1911                   ,disable <var processor: application mp> power switch  this field is used to disable the <var processor: application mp> power switch sleep power down during mp subsystem power down mode.  1 = disable mp power switch sleep" "0,1"
        bitfld.long 0x00 16. "   MP_L2_PWR_OFF1913                    ,frc l2 sram off  1 = l2 cache power is off" "0,1"
        bitfld.long 0x00 13. "   L2_HW_CACHE_FLUSH_EN1915         ,l2 hardware cache flush enable  0x1= enable" "0,1"
        textline "                                      "
        bitfld.long 0x00 12. "MASK_SRAM_REPAIR_DONE_CHECK1916 ,mask sram repair done check  1 = mask sram repair done check" "0,1"
        bitfld.long 0x00 11. "         MASK_CLK_OFF_CHECK1917           ,mask <var processor: application mp> clock off state check  this field is used to mask the <var processor: application mp> clock off check during the mp idle process." "0,1"
        bitfld.long 0x00 10. "   MASK_CLK_STBL_CHECK1918              ,mask mp clock stbl state check  this field is used to mask the mp clock stable check during mp wakeup." "0,1"
        bitfld.long 0x00 9. "   MASK_JTAG_IDLE_CHECK1919         ,mask jtag idle state check  this field is used to mask the jtag idle check during <var processor: application mp> idle entry.  1 = mask jtag idle check" "0,1"
        textline "                                      "
        bitfld.long 0x00 8. "MASK_IDLE_CHECK1920             ,mask <var processor: application mp> idle state check  debug only - it should be 0 during normal operation  1 = status check masked  0 = status check not masked" "0,1"
        bitfld.long 0x00 7. "         ACINACTM_HW_CTRL1921             ,acinactm hardware control   0x0=low power state machine does not control acinactm port.   0x1= low power state machine will control acinactm port of <var processor: application mp>.  when m2/m1 low power mode is entered, acinactm port will be high" "0,1"
        bitfld.long 0x00 5. "   DIS_MC_SW_REQ1923                    ,disable memory controller software req  this field is used to disable the memory controller entry to idle mode using the memory controller sleep request bits. the memory controller will always enter into idle mode based upon the hardware state machine re" "0,1"
        bitfld.long 0x00 4. "   MP_WAKE_MC_EN1924                ,<var processor: application mp> wake mc enable  wake up the memory controller when the <var processor: application mp> wakes up from idle mode. the memory controller will be woken up before the interrupt to the core is released.  0 = memory controller w" "0,1"
        textline "                                      "
        bitfld.long 0x00 3. "MP_SCU_SRAM_PWRDWN1925          ,not used. scu sram does not support retention" "0,1"
        bitfld.long 0x00 3. "         PM_1926                          ,reserved for future use" "0,1"
        bitfld.long 0x00 2. "   L2_SRAM_PWRDWN1927                   ,l2 cache sram power down  this field does not take effect if mp_pwrdwn is 0.  1 = when <var processor: application mp> is idle, l2 sram power will be off  0 = when <var processor: application mp> is idle, l2 sram is in retention mode" "0,1"
        bitfld.long 0x00 1. "   MP_PWRDWN1928                    ,<var processor: application mp> power down  this field does not take effect if mp_idle is 0.  1 = when <var processor: application mp> is idle, <var processor: application mp> will go into deep sleep mode and <var processor: application mp> logic will b" "0,1"
        textline "                                      "
        bitfld.long 0x00 0. "MP_IDLE1929                     ,<var processor: application mp> idle  1 = when <var processor: application mp> is idle, <var processor: application mp> clocks will be gated externally" "0,1"

group d:0xD4282B70++0x03
    line.long 0x00 "PMU_CORE2_STATUS2,Core Status2 Register"
        bitfld.long 0x00 9. " AP_CORE9_C2                     ,<var processor: application> core9 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core9 is in c2 mode.  1 = <var processor: application> core9 is in c2 mode" "0,1"
        bitfld.long 0x00 8. "         AP_CORE9_C1                      ,<var processor: application> core1 in c9 mode indication  this field is used to indicate whether or not <var processor: application> core9 is in c1 mode.  1 = <var processor: application> core9 is in c1 mode (here c1 means external idle mode)" "0,1"
        bitfld.long 0x00 7. "   AP_CORE9_WFI_FLAG                    ,<var processor: application> core9 wfi flag  this field reflects the wfi flag that is generated by core1. when core9 enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 6. "   AP_CORE8_C2                      ,<var processor: application> core8 in c2 mode indication  this field is used to indicate whether or not <var processor: application> core8 is in c2 mode.  1 = <var processor: application> core8 is in c2 mode" "0,1"
        textline "                                      "
        bitfld.long 0x00 5. "AP_CORE8_C1                     ,<var processor: application> core8 in c1 mode indication  this field is used to indicate whether or not <var processor: application> core8 is in c1 mode.  1 = <var processor: application> core8 is in c1 mode (here c1 means external idle mode)" "0,1"
        bitfld.long 0x00 4. "         AP_CORE8_WFI_FLAG                ,<var processor: application> core8 wfi flag  this field reflects the wfi flag that is generated by core8. when core8 enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 3. "   AP_C2_MPSUB_M2                       ,<q><var processor: application mp> cluster2 subsystem idle mode<\q> indication  this field is used to indicate whether or not the <var processor: application mp> subsystem is in m2 mode.  1 = <var processor: application mp> subsystem is in m2 mode" "0,1"
        bitfld.long 0x00 2. "   AP_C2_MPSUB_M1                   ,<var processor: application mp> cluster2 subsystem in m1 mode indication  this field is used to indicate whether or not the <var processor: application mp> subsystem is in m1 mode.  1 = <var processor: application mp> subsystem is in m1 mode (here m1 means <var processor: application mp> subsystem external idle mode)" "0,1"
        textline "                                      "
        bitfld.long 0x00 1. "AP_C2_MPSUB_IDLE_FLAG           ,<var processor: application mp> cluster2  subsystem idle flag  this field reflects the and logic value of scu_idle and l2clkstopped generated in the <var processor: application mp> subsystem.  1 = core8/core9/scu/l2 are all in idle state" "0,1"

tree.end

tree "dsi"

width 22.

group d:0xD4238000++0x03
    line.long 0x00 "DSI_CTRL_0,DSI Control Register 0"
        bitfld.long 0x00 31. " CFG_SOFT_RST              ,software reset dsi module  1 = reset dsi module  0 = de-assert software reset" "0,1"
        bitfld.long 0x00 30. "         CFG_SOFT_RST_REG          ,software reset config registers  1 = reset dsi config registers to default values  0 = de-assert reset" "0,1"
        bitfld.long 0x00 29. "     CFG_CLR_PHY_FIFO         ,configure clear phy tx fifo  1 = clear fifo data to 0  0 = de-assert clear. it is not used currently and reserved for future use." "0,1"
        bitfld.long 0x00 28. "       CFG_RST_TXLP              ,software reset lp tx submodule  1 = reset lp tx module  0 = de-assert software reset" "0,1"
        textline "                                "
        bitfld.long 0x00 27. "CFG_RST_CPU               ,software reset cpu tx submodule  1 = reset cpu tx module  0 = de-assert software reset" "0,1"
        bitfld.long 0x00 26. "         CFG_RST_CPN               ,software reset cpn tx submodule  1 = reset cpn tx module  0 = de-assert software reset" "0,1"
        bitfld.long 0x00 24. "     CFG_RST_VPN              ,software reset video panel submodule  1 = reset vpn module  0 = de-assert software reset" "0,1"
        bitfld.long 0x00 23. "       CFG_DSI_PHY_RST           ,software reset dphy submodule  1 = reset dphy  0 = de-assert software reset" "0,1"
        textline "                                "
        bitfld.long 0x00 17. "CFG_DSI_HCLK_DIS          ,dsi ahb clock disable. dsi config registers can still be written or read even if dsi ahb clock is disabled.  1 = dsi ahb clock will be gated   0 = dsi ahb clock is passed to dsi module" "0,1"
        bitfld.long 0x00 16. "         CFG_DSI_CLK_DIS           ,dsi clock disable  1 = dsi clock will be gated   0 = dsi clock is passed to dsi module" "0,1"
        bitfld.long 0x00 8. "     CFG_VPN_TX_EN            ,video panel interface tx enable  1 = enable video panel tx packet to dphy. dsi will send video packets to peripheral.   0 = disable video panel interface tx." "0,1"
        bitfld.long 0x00 4. "       CFG_VPN_SLV               ,video panel interface in slave mode  1 = video panel work in slave mode, and it will receive vsync from input lcd interface, and use it to control the internal timing.   0 = video panel interface works in master mode. dsi will send vsync to lcd module and control the v timing and h timing.   this bit must set to 1, vpn just support slave mode." "0,1"
        textline "                                "
        bitfld.long 0x00 2. "CFG_CPN_EN                ,command panel interface enable  1 = command panel is running and can accept data from the command panel interface  0 = disable command panel interface." "0,1"
        bitfld.long 0x00 0. "         CFG_VPN_EN                ,video panel interface enable  1 = video panel is running.  0 = disable video panel interface.   setting this field to 1 will star the video panel timing." "0,1"

group d:0xD4238004++0x03
    line.long 0x00 "DSI_CTRL_1,DSI Control Register 1"
        bitfld.long 0x00 8. " CFG_EOTP_EN               ,eotp enable  1 = enable eotp packet  0 = disable eotp packet" "0,1"
        bitfld.long 0x00 6.--7. "         CFG_CPN_VCH_NO            ,command panel virtual channel number" "0,1,2,3"
        bitfld.long 0x00 0.--1. "     CFG_VPN_VCH_NO           ,video panel virtual channel number for active panel 1  this parameter defines the virtual channel number for vpn" "0,1,2,3"

group d:0xD4238008++0x03
    line.long 0x00 "DSI_IRQ_ST1,DSI Interrupt Status Register1"
        bitfld.long 0x00 3. " IRQ_DPHY_ERR_HS_RXP       ,dphy hstx contention rxp error" "0,1"
        bitfld.long 0x00 2. "         IRQ_DPHY_ERR_HS_RXN       ,dphy hstx contention rxn error" "0,1"
        bitfld.long 0x00 1. "     IRQ_DPHY_ERR_HS_CONTP    ,dphy hstx contention contp error" "0,1"
        bitfld.long 0x00 0. "       IRQ_DPHY_ERR_HS_CONTN     ,dphy hstx contention contn error" "0,1"

group d:0xD423800C++0x03
    line.long 0x00 "DSI_IRQ_MASK1,DSI Interrupt Mask Register1"
        bitfld.long 0x00 0.--3. " CFG_IRQ_MASK1             ,dsi interrupt mask  this field is used to mask interrupt requests. if one bit is set to 0x1, the corresponding interrupt status is masked." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4238010++0x03
    line.long 0x00 "DSI_IRQ_ST,DSI Interrupt Status Register"
        bitfld.long 0x00 31. " IRQ_LAST_LINE             ,last line interupt" "0,1"
        bitfld.long 0x00 30. "         IRQ_CPN_TE                ,command panel tearing effect." "0,1"
        bitfld.long 0x00 29. "     IRQ_TA_TIMEOUT           ,turnaround acknowledge timeout for dphy" "0,1"
        bitfld.long 0x00 28. "       IRQ_RX_TIMEOUT            ,lp-rx timeout for dphy" "0,1"
        textline "                                "
        bitfld.long 0x00 27. "IRQ_TX_TIMEOUT            ,hs tx timeout for dphy" "0,1"
        bitfld.long 0x00 26. "         IRQ_RX_STATE_ERR          ,peripheral status error  after dsi receives an ack with error report packet from slave, it will mark this bit if there is error status reported." "0,1"
        bitfld.long 0x00 25. "     IRQ_RX_ERR               ,dsi rx packet error  dsi receives a packet from slave and the received packet has error status (ecc error/crc error/unknown packet)" "0,1"
        bitfld.long 0x00 24. "       IRQ_RX_FIFO_FULL_ERR      ,rx fifo full error" "0,1"
        textline "                                "
        bitfld.long 0x00 23. "IRQ_PHY_FIFO_UNDERRUN     ,phy fifo underrun error" "0,1"
        bitfld.long 0x00 22. "         IRQ_REQ_CNT_ERR           ,tx request count error  the delays between an active panel tx request to the dphy ready are not consistent." "0,1"
        bitfld.long 0x00 21. "     IRQ_RXPSR_FIFO_FULL_ERR  ,rx parser fifo full error" "0,1"
        bitfld.long 0x00 20. "       IRQ_VPN_REQ_PHY_DLY_ERR   ,vpn request delay error at phy interface  vpn packets are delayed at the phy interface." "0,1"
        textline "                                "
        bitfld.long 0x00 19. "IRQ_VPN_BF_UNDERRUN_ERR   ,vpn buffer underrun error" "0,1"
        bitfld.long 0x00 18. "         IRQ_VPN_REQ_ARB_DLY_ERR   ,vpn request delay error at arbiter interface  vpn packets are delayed at arbiter point." "0,1"
        bitfld.long 0x00 17. "     IRQ_VPN_BF_OVERRUN_ERR   ,vpn buffer overrun error" "0,1"
        bitfld.long 0x00 16. "       IRQ_VPN_TIMING_ERR        ,vpn data timing error  pixel data may be incorrect. data fifo for vpn path is read too early or too late, and fifo is empty when it is read." "0,1"
        textline "                                "
        bitfld.long 0x00 15. "IRQ_VPN_VACT_DONE         ,vpn vact done" "0,1"
        bitfld.long 0x00 14. "         IRQ_VPN_BF_FULL           ,vpn buffer full error  pixel data may be incorrect." "0,1"
        bitfld.long 0x00 13. "     IRQ_CPN_BF_FULL          ,cpn buffer full error  pixel data may be incorrect." "0,1"
        bitfld.long 0x00 12. "       IRQ_DPHY_ERR_CONT_LP1     ,dphy lp1 contention detect  ppi errcontertionlp1" "0,1"
        textline "                                "
        bitfld.long 0x00 11. "IRQ_DPHY_ERR_CONT_LP0     ,dphy lp0 contention detect  ppi errcontertionlp0" "0,1"
        bitfld.long 0x00 10. "         IRQ_DPHY_ERR_SYNC_ESC     ,dphy sync error  ppi errsyncesc, partial byte detected" "0,1"
        bitfld.long 0x00 9. "     IRQ_DPHY_ERR_ESC         ,dphy invalid command detect  ppi erresc, invalid esc command detected" "0,1"
        bitfld.long 0x00 8. "       IRQ_DPHY_RX_LINE_ERR      ,dphy invalid line state detect  ppi errcontrol" "0,1"
        textline "                                "
        bitfld.long 0x00 7. "IRQ_RX_TRG3               ,dphy rx trigger 3 received  by default, the value of trigger 3 is 0x05, and its meaning is not defined by specification." "0,1"
        bitfld.long 0x00 6. "         IRQ_RX_TRG2               ,dphy rx trigger 2 received  by default, trigger 2 is for acknowledge trigger, and its value is 0x84." "0,1"
        bitfld.long 0x00 5. "     IRQ_RX_TRG1              ,dphy rx trigger 1 received  by default, trigger 1 is for te trigger, and its value is 0xba." "0,1"
        bitfld.long 0x00 4. "       IRQ_RX_TRG0               ,dphy rx trigger 0 received  by default, trigger 0 is for reset trigger, and its value is 0x46." "0,1"
        textline "                                "
        bitfld.long 0x00 3. "IRQ_RX_ULPS               ,dphy rx ulps received" "0,1"
        bitfld.long 0x00 2. "         IRQ_RX_PKT                ,dphy rx packet received" "0,1"
        bitfld.long 0x00 1. "     IRQ_CPN_TX_DONE          ,command panel data transmission done" "0,1"
        bitfld.long 0x00 0. "       IRQ_CPU_TX_DONE           ,cpu packet transmission done" "0,1"

group d:0xD4238014++0x03
    line.long 0x00 "DSI_IRQ_MASK,DSI Interrupt Mask Register"
        hexmask.long 0x00 0.--31. 1. " CFG_IRQ_MASK              ,dsi interrupt mask  this field is used to mask interrupt requests. if one bit is set to 0x1, the corresponding interrupt status is masked."

group d:0xD4238018++0x03
    line.long 0x00 "DSI_FPGA_PHY_CTRL_0,DSI FPGA PHY Control Register 0"
        bitfld.long 0x00 14. " CFG_DPHY_FCLK_REV         ,fpga dphy fclk reverse" "0,1"
        bitfld.long 0x00 13. "         CFG_DPHY_TXRX_BYTECLK_REV ,fpga dphy txrx_byteclk reverse" "0,1"
        bitfld.long 0x00 12. "     CFG_DPHY_HSREQ_LANE3     ,fpga dphy lane3 hs requeset" "0,1"
        bitfld.long 0x00 11. "       CFG_DPHY_HSREQ_LANE2      ,fpga dphy lane2 hs requeset" "0,1"
        textline "                                "
        bitfld.long 0x00 10. "CFG_DPHY_HSREQ_LANE1      ,fpga dphy lane1 hs requeset" "0,1"
        bitfld.long 0x00 9. "         CFG_DPHY_HSREQ_LANE0      ,fpga dphy lane0 hs requeset" "0,1"
        bitfld.long 0x00 8. "     CFG_DPHY_HSREQ_LANECLK   ,fpga dphy laneclk hs requeset" "0,1"
        bitfld.long 0x00 7. "       CFG_DPHY_ENABLECLK        ,fpga dphy enable clk lane" "0,1"
        textline "                                "
        bitfld.long 0x00 6. "CFG_DPHY_ENABLE1125       ,fpga dphy enable1" "0,1"
        bitfld.long 0x00 5. "         CFG_DPHY_ENABLE0126       ,fpga dphy enable0" "0,1"
        bitfld.long 0x00 4. "     CFG_DPHY_MASSLVZ127      ,fpga dphy masterslaverz" "0,1"
        bitfld.long 0x00 3. "       CFG_DPHY_TXRXZ            ,reserved for future use" "0,1"
        textline "                                "
        bitfld.long 0x00 2. "CFG_DPHY_RSTZCAL129       ,fpga dphy rstzcal" "0,1"
        bitfld.long 0x00 1. "         CFG_DPHY_SHUTDOWN130      ,fpga dphy shutdown" "0,1"
        bitfld.long 0x00 0. "     CFG_DPHY_RESETZ131       ,fpga dphy resetz" "0,1"

group d:0xD423801C++0x03
    line.long 0x00 "DSI_FPGA_PHY_CTRL_1,DSI FPGA PHY Control Register 1"
        bitfld.long 0x00 24. " CFG_DPHY_ENABLE1139       ,fpga dphy lock" "0,1"
        hexmask.long.byte 0x00 16.--23. 1. "         CFG_DPHY_ENABLE0140       ,fpga dphy testdout"
        hexmask.long.byte 0x00 8.--15. 1. "    CFG_DPHY_MASSLVZ141      ,fpga dphy testdin"
        bitfld.long 0x00 2. "      CFG_DPHY_RSTZCAL143       ,fpga dphy testen" "0,1"
        textline "                                "
        bitfld.long 0x00 1. "CFG_DPHY_SHUTDOWN144      ,fpga dphy testclr" "0,1"
        bitfld.long 0x00 0. "         CFG_DPHY_RESETZ145        ,fpga dphy testclk" "0,1"

group d:0xD4238020++0x03
    line.long 0x00 "DSI_CPU_CMD_0,DSI CPU Packet Command Register 0"
        bitfld.long 0x00 31. " CFG_CPU_CMD_REQ           ,cpu command request  1 = cpu packet request  0 = no request or request done  after software writes a command with this bit set to 1, the dsi module sends out a packet as requested. dsi de-asserts this field after packet is sent." "0,1"
        bitfld.long 0x00 30. "         CFG_CPU_SP                ,cpu short packet  1 = cpu packet is a short packet  0 = cpu packet is a long packet" "0,1"
        bitfld.long 0x00 29. "     CFG_CPU_TURN             ,cpu turn around  1 = after cpu packet, turn around the bus  0 = don’t turn around bus after cpu packet" "0,1"
        bitfld.long 0x00 27. "       CFG_CPU_TXLP              ,low power tx for cpu packets  1 = transfer cpu packets through low power mode  0 = use high-speed mode to send cpu packets" "0,1"
        textline "                                "
        hexmask.long.word 0x00 0.--15. 1. "CFG_CPU_WC                ,cpu packet byte count  for high speed transfer, this is the payload byte count for long packets and doesn't include crc bytes. for high speed short packet transfer, this parameter is ignored. for low power transfer, this is the byte count for the whole packet transmission, including crc bytes, and cfg_cpu_sp is ignored."

group d:0xD4238024++0x03
    line.long 0x00 "DSI_CPU_CMD_1,DSI CPU Packet Command Register 1"
        bitfld.long 0x00 20.--23. " CFG_TXLP_LPDT             ,lpdt tx enable  lpdt tx enable signals for low power tx" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "        CFG_TXLP_ULPS             ,ulps tx enable  ulps tx enable signals for low power tx" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.word 0x00 0.--15. 1. "    CFG_TXLP_TRIGGER_CODE    ,low power tx trigger code"

group d:0xD423802C++0x03
    line.long 0x00 "DSI_CPU_CMD_3,DSI CPU Packet Command Register 3"
        bitfld.long 0x00 31. " CFG_CPU_DAT_REQ           ,cpu packet data buffer read/write request  1 = cpu packet data request   0 = no request or request done  after software writes a command with this bit set to 1, the dsi module will write data to the packet data buffer or read data from the data buffer as requested. dsi will de-assert this bit after write/read operation is done. read data will be valid after this bit is reset to zero." "0,1"
        bitfld.long 0x00 30. "         CFG_CPU_DAT_RW            ,cpu packet data buffer read/write operation  1 = cpu packet data write operation   0 = cpu packet data read operation" "0,1"
        hexmask.long.byte 0x00 16.--23. 1. "     CFG_CPU_DAT_ADDR         ,cpu packet data address  this is the byte address for packet data. every write/read operation, 4 bytes of data will be written or read. software should increase address by 4 after each operation. packet data start from packet header. address 0: bits [7:0] are for type_id, bits [23:8] are for length, and bits [31:24] are for ecc. address 4: payload data if packet is a long packet, and so on. the maximum packet data buffer is 256 bytes."

group d:0xD4238030++0x03
    line.long 0x00 "DSI_CPU_WDAT,DSI CPU Packet Data Register"
        hexmask.long 0x00 0.--31. 1. " CFG_CPU_WDAT              ,cpu wdata 0  the dsi can generate packets based on cpu programmed data. this register defines the cpu packet data.  this register is the cpu packet data to be written to the packet data buffer. software should program packet data to this register and then program the dsi cpu packet command register 3 to put the packet data into the tx packet data buffer. for every write/read operation, 4-byte data is written/read. bits [7:0] are the lsb and bits [31:24] are the msb.  for packet data at address 0, bits [7:0] are for type_id, bits [23:8] are for length, and bits [31:24] are for ecc.  for data at address 4, payload data if packet is a long packet, and so on.  if packet is transmitted in high speed, hardware generates ecc and crc to replace this ecc/crc code in the packet data buffer. under low power tx, hardware does not insert ecc/crc and sends out the ecc/crc code in the packet data buffer."

group d:0xD4238034++0x03
    line.long 0x00 "DSI_CPU_STATUS_0,DSI CPU Command Status 0"
        hexmask.long.word 0x00 0.--15. 1. " CFG_CPU_PKT_CNT           ,cpu packet counter  this counter counts how many cpu packets are sent out through dsi. this register is write clear."

group d:0xD4238038++0x03
    line.long 0x00 "DSI_CPU_STATUS_1,DSI CPU Command Status 1"
        hexmask.long 0x00 0.--31. 1. " CFG_CPU_CMD_TX_CNT        ,cpu cmd tx counter  this counter counts how many byte clock cycles it takes to transfer the current cpu command. it begins to count after cpu command is received, and stops to counter after dphy gets ready for another tx request. this counter could help to decide the cfg_l*_slot_**_cnt values of register 0x130, 0x134, 0x1b0, and 0x1b4."

group d:0xD423803C++0x03
    line.long 0x00 "DSI_CPU_STATUS_2,DSI CPU Command Status 2"
        hexmask.long 0x00 0.--31. 1. " CFG_CPU_CMD_CNT           ,cpu cmd execution counter  this counter counts how many byte clock cycles it takes to execute the current cpu command. this counter only counts the cycles which cpu engine is busy. this counter could help to decide the cfg_l*_slot_**_cnt values of register 0x130, 0x134, 0x1b0, and 0x1b4."

group d:0xD4238040++0x03
    line.long 0x00 "DSI_CPU_STATUS_3,DSI CPU Command Status 3"
        hexmask.long 0x00 0.--31. 1. " CFG_TXLP_CNT              ,low power tx byte clock count. this counter counts how many byte clock cycles it takes to transfer a low power packet."

group d:0xD4238044++0x03
    line.long 0x00 "DSI_CPU_STATUS_4,DSI CPU Command Status 4"
        hexmask.long 0x00 0.--31. 1. " CFG_BTA_CNT               ,bus turn around byte clock count. this counter counts how many byte clock cycles it takes to do a bus turn around operation."

group d:0xD423804C++0x03
    line.long 0x00 "DSI_CPN_STATUS_1,DSI Command Panel Path Status 1"
        hexmask.long 0x00 0.--31. 1. " CFG_CPN_STATUS_1          ,command panel path status 1.  {smt_bf_cnt[5:0], smt_fifo_bcnt[9:0],   3'b0, smt_cs[4:0],    2'b0, smt_wr_on, smt_dma_on,   smt_fifo_empty, smt_bf_empty, smt_fifo_full_r, smt_bf_full_r}"

group d:0xD4238050++0x03
    line.long 0x00 "DSI_CPN_CMD,DSI Command Panel Command Register"
        bitfld.long 0x00 28.--31. " CFG_CPN_TE_EN             ,command panel tearing effect signal enable" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--26. "        CFG_CPN_RGB_TYPE          ,command panel data rgb type  0x0 = 888 mode  0x1 = 666 unpacked mode  0x2 = 565 mode  0x3 = 444 mode  0x4 = 332 mode  0x5 = 111 mode" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 3. "     CFG_CPN_BURST_MODE       ,command panel interface burst mode enable   0 = enable previous command pandel interface.   1 = burst mode interface between lcd and dsi will take effect.  this interface is more efficient than the previous one." "0,1"
        bitfld.long 0x00 2. "       CFG_CPN_FIRSTP_SEL        ,command panel first packet select   0 = fifo empty <1> vsync from dp650" "0,1"
        textline "                                "
        bitfld.long 0x00 1. "CFG_CPN_DMA_DIS           ,command panel dma_on disable  1 = disable smt_dma_on signal from lcd controller. dsi will not receive command panel interface data from lcd even smt_dma_on signal is active high.  0 = receive lcd command panel interface data when smt_dma_on is high." "0,1"
        bitfld.long 0x00 0. "         CFG_CPN_ADDR0_EN          ,command panel address bit indicator  0 = when smt_addr = 1, bus data are for pixel rgb data. when smt_addr = 0, bus data are ignored  1 = when smt_addr = 0, bus data are for pixel rgb data. when smt_addr = 1, bus data are ignored." "0,1"

group d:0xD4238054++0x03
    line.long 0x00 "DSI_CPN_CTRL_0,DSI Command Panel Control 0 Register"
        hexmask.long.byte 0x00 16.--21. 1. " CFG_DCS_LONGWR_CODE       ,dsi command code for writing command panel data  the default data is 0x39 from dsi specification."
        hexmask.long.byte 0x00 8.--15. 1. "        CFG_DCS_WR_CON_CODE       ,dcs command for continuous write  the default value is 0x3c in mipi alliance standard for display command set specification."
        hexmask.long.byte 0x00 0.--7. 1. "    CFG_DCS_WR_STR_CODE      ,dcs command for first write  the default value is 0x2c in the mipi alliance standard for display command set specification."

group d:0xD4238058++0x03
    line.long 0x00 "DSI_CPN_CTRL_1,DSI Command Panel Control 1 Register"
        hexmask.long.word 0x00 16.--25. 1. " CFG_CPN_PKT_CNT           ,command panel packet length  this field defines the packet length for command panel packets."
        hexmask.long.word 0x00 0.--9. 1. "      CFG_CPN_FIFO_FULL_LEVEL   ,command panel fifo full level, in byte count"

group d:0xD423805C++0x03
    line.long 0x00 "DSI_CPN_STATUS_0,DSI Command Panel Control Status 0"
        hexmask.long 0x00 0.--31. 1. " CFG_CPN_FRM_CNT           ,command panel frame counter  this counter counts how many command panel frames are sent out through dsi. this register is write clear."

group d:0xD4238060++0x03
    line.long 0x00 "DSI_RX_PKT_ST_0,DSI RX Packet 0 Status Register"
        bitfld.long 0x00 31. " RX_PKT0_ST_VLD            ,rx packet 0 status valid  1 = valid status  0 = invalid status" "0,1"
        bitfld.long 0x00 26. "         RX_PKT0_ST_EOTP           ,rx packet 0 is eotp  1 = received packet is eotp packet  0 = other packet  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 25. "     RX_PKT0_ST_ACK           ,rx packet 0 is ack packet  1 = received packet is an ack packet with or without error  0 = other packet  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 24. "       RX_PKT0_ST_SP             ,rx packet 0 short packet  1 = received packet is a short packet  0 = long packet  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        textline "                                "
        hexmask.long.byte 0x00 16.--21. 1. "RX_PKT0_PKT_PTR           ,rx packet 0 data pointer  packet header in fifo is the raw data from dphy and is before ecc correction.  it is valid only when rx_pkt0_st_vld = 1."
        bitfld.long 0x00 14.--15. "        RX_PKT0_VCH               ,rx packet 0 virtual channel number  it is valid only when rx_pkt0_st_vld = 1." "0,1,2,3"
        bitfld.long 0x00 8.--11. "     RX_PKT0_ECC_FLAGS        ,rx packet 0 ecc error flags  bit [11]:  1 = no ecc error  0 = ecc error    bit [10]:  1 = correctable error in data bits    bit [9]:  1 = correctable error happens at parity bits    bit [8]: 1 = incorrectable error  it is valid only when rx_pkt0_st_vld = 1." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4. "      RX_PKT0_NO_CRC            ,rx packet 0 without crc  rx packet doesn't contain crc and crc part contain 0x0000. it is valid only when rx_pkt0_st_vld = 1." "0,1"
        textline "                                "
        bitfld.long 0x00 3. "RX_PKT0_UNKNOWN_ERR       ,rx packet 0 type unknown error  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 2. "         RX_PKT0_ST_ERR            ,rx packet 0 ack status error  the ack packet has error status. the dsi_rx_pkt_hdr_0 should be checked to see what error happens. it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 1. "     RX_PKT0_ECC_ERR          ,rx packet 0 ecc error  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 0. "       RX_PKT0_CRC_ERR           ,rx packet crc error  it is valid only when rx_pkt0_st_vld = 1." "0,1"

group d:0xD4238064++0x03
    line.long 0x00 "DSI_RX_PKT_HDR_0,DSI RX Packet 0 Header Register"
        hexmask.long 0x00 0.--31. 1. " RX_PKT0_HDR               ,rx packet 0 header  bits [7:0]: dataid  bits [23:8]: length  bits [31:23]: ecc--corrected if error detected."

group d:0xD4238068++0x03
    line.long 0x00 "DSI_RX_PKT_ST_1,DSI RX Packet 1 Status Register"
        bitfld.long 0x00 31. " RX_PKT1_ST_VLD            ,rx packet 1 status valid  1 = valid status  0 = invalid status" "0,1"
        bitfld.long 0x00 26. "         RX_PKT1_ST_EOTP           ,rx packet 1 is eotp  1 = received packet is eotp packet  0 = other packet  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 25. "     RX_PKT1_ST_ACK           ,rx packet 1 is ack packet  1 = received packet is an ack packet with or without error  0 = other packet  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 24. "       RX_PKT1_ST_SP             ,rx packet 1 short packet  1 = received packet is a short packet  0 = long packet valid only when rx_pkt0_st_vld = 1." "0,1"
        textline "                                "
        hexmask.long.byte 0x00 16.--21. 1. "RX_PKT1_PKT_PTR           ,rx packet 1 data pointer  packet header in fifo is the raw data from dphy and is before ecc correction.  valid only when rx_pkt0_st_vld = 1."
        bitfld.long 0x00 14.--15. "        RX_PKT1_VCH               ,rx packet 1 virtual channel number  valid only when rx_pkt0_st_vld = 1." "0,1,2,3"
        bitfld.long 0x00 8.--11. "     RX_PKT1_ECC_FLAGS        ,rx packet 1 ecc error flags  bit [11]:  1 = no ecc error  0 = ecc error    bit [10]:  1 = correctable error in data bits    bit [9]:  1 = correctable error happens at parity bits    bit [8]:  1 = incorrectable error  it is valid only when rx_pkt0_st_vld = 1." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4. "      RX_PKT1_NO_CRC            ,rx packet 1 without crc  rx packet doesn't contain crc and crc part contain 0x0000. it is valid only when rx_pkt0_st_vld = 1." "0,1"
        textline "                                "
        bitfld.long 0x00 3. "RX_PKT1_UNKNOWN_ERR       ,rx packet type unknown error  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 2. "         RX_PKT1_ST_ERR            ,rx packet 1 ack status error  the dsi_rx_pkt_hdr_0 should be checked to see what error happens. it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 1. "     RX_PKT1_ECC_ERR          ,rx packet 1 ecc error  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 0. "       RX_PKT1_CRC_ERR           ,rx packet 1 crc error  it is valid only when rx_pkt0_st_vld = 1." "0,1"

group d:0xD423806C++0x03
    line.long 0x00 "DSI_RX_PKT_HDR_1,DSI RX Packet 1 Header Register"
        hexmask.long 0x00 0.--31. 1. " RX_PKT1_HDR               ,rx packet 1 header"

group d:0xD4238070++0x03
    line.long 0x00 "DSI_RX_PKT_CTRL,DSI RX Packet Read Control Register"
        bitfld.long 0x00 31. " RX_PKT_RD_REQ             ,rx packet fifo read request  1 = read request  0 = invalid req  this bit will be cleared to 0 after read operation is done and rx data valid." "0,1"
        hexmask.long.byte 0x00 16.--21. 1. "         RX_PKT_RD_PTR             ,rx packet data fifo read pointer  for every read operation, the hardware will return the data from the pointer address. software must increment this pointer for the next data after each byte is read."
        hexmask.long.byte 0x00 0.--7. 1. "    RX_PKT_RD_DATA           ,rx fifo read data  valid when rx_pkt_rd_req = 0.  first byte: dataid  second byte: wc0  third byte: wc1  fourth byte: raw ecc received from dphy, not corrected  fifth byte and beyond: long packet data"

group d:0xD4238074++0x03
    line.long 0x00 "DSI_RX_PKT_CTRL_1,DSI RX Packet Read Control 1 Register"
        bitfld.long 0x00 8.--11. " RX_PKT_CNT                ,rx packet count in rx fifo  all lp rx packets are stored in the fifo and start from address 0." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        hexmask.long.byte 0x00 0.--7. 1. "        RX_PKT_BCNT               ,rx byte count in rx fifo  the whole lp rx data are stored in the fifo and start from address 0."

group d:0xD4238078++0x03
    line.long 0x00 "DSI_RX_PKT_ST_2,DSI RX Packet 2 Status Register"
        bitfld.long 0x00 31. " RX_PKT2_ST_VLD            ,rx packet 2 status valid  1 = valid status  0 = invalid status" "0,1"
        bitfld.long 0x00 26. "         RX_PKT2_ST_EOTP           ,rx packet 2 is eotp  1 = received packet is eotp packet  0 = other packet  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 25. "     RX_PKT2_ST_ACK           ,rx packet 2 is an ack packet<p>1 = received packet is a ack packet with or without error  0 = other packet  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 24. "       RX_PKT2_ST_SP             ,rx packet 2 short packet  1 = received packet is a short packet  0 = long packet  valid only when rx_pkt0_st_vld = 1." "0,1"
        textline "                                "
        hexmask.long.byte 0x00 16.--21. 1. "RX_PKT2_PKT_PTR           ,rx packet 2 data pointer  packet header in fifo is the raw data from dphy and is before ecc correction. valid only when rx_pkt0_st_vld = 1."
        bitfld.long 0x00 14.--15. "        RX_PKT2_VCH               ,rx packet 2 virtual channel number  valid only when rx_pkt0_st_vld = 1." "0,1,2,3"
        bitfld.long 0x00 8.--11. "     RX_PKT2_ECC_FLAGS        ,rx packet 2 ecc error flags  bit [11]:   1 = no ecc error  0 = ecc error    bit [10]:  1 = correctable error in data bits    bit [9]:  1 = correctable error happens at parity bits    bit [8]:  1 = incorrectable error  it is valid only when rx_pkt0_st_vld = 1." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4. "      RX_PKT2_NO_CRC            ,rx packet 2 without crc  rx packet doesn't contain crc and crc part contain 0x0000. it is valid only when rx_pkt0_st_vld = 1." "0,1"
        textline "                                "
        bitfld.long 0x00 3. "RX_PKT2_UNKNOWN_ERR       ,rx packet 2 type unknown error  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 2. "         RX_PKT2_ST_ERR            ,rx packet 2 ack status error  the dsi_rx_pkt_hdr_0 should be checked to see what error happens. it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 1. "     RX_PKT2_ECC_ERR          ,rx packet 2 ecc error  it is valid only when rx_pkt0_st_vld = 1." "0,1"
        bitfld.long 0x00 0. "       RX_PKT2_CRC_ERR           ,rx packet 2 crc error  it is valid only when rx_pkt0_st_vld = 1." "0,1"

group d:0xD423807C++0x03
    line.long 0x00 "DSI_RX_PKT_HDR_2,DSI RX Packet 2 Header Register"
        hexmask.long 0x00 0.--31. 1. " RX_PKT2_HDR               ,rx packet 2 header"

group d:0xD4238084++0x03
    line.long 0x00 "DSI_LCD_BDG_CTRL0,DSI LCD Bridge Control Register 0"
        hexmask.long.word 0x00 16.--27. 1. " CFG_VPN_FIFO_AFULL_CNT    ,dsi vpn fifo almost full count vpn fifo read_point - write_point shoud be greater than this value"
        bitfld.long 0x00 9. "      CFG_HSYNC_MISSING_FIX     ,fix the hsync missing bug" "0,1"
        bitfld.long 0x00 8. "     CFG_TXLP_LANE_TURN_FIX   ,fix the txlp lane turn bug" "0,1"
        bitfld.long 0x00 6. "       CFG_VPN_FIFO_AFULL_BYPASS ,by pass vpn fifo almost full  0 = not bypass  1 = bypass, the lcd output pixel data to vpn fifo  not care the almost full signal" "0,1"
        textline "                                "
        bitfld.long 0x00 5. "CFG_CPN_VSYNC_EDGE        ,cpn vsync signal edge select  0 = posedge select  1 = negedge select" "0,1"
        bitfld.long 0x00 4. "         CFG_CPN_TE_EDGE           ,cpn tearing effect signal edge select  0 = posedge select  1 = negedge select" "0,1"
        bitfld.long 0x00 2.--3. "     CFG_CPN_TE_MODE          ,cpn tearing effect mode select  0 = no tearing effect  1 = mode a, tearing effect signal consists of v-blanking only   2 = mode b, tearing effect signal consists of v-blanking and h-blanking  3 = mode c, tearing effect signal output the n h-blanking" "0,1,2,3"
        bitfld.long 0x00 1. "       CFG_PIXEL_SWAP            ,lcd output pixel swap  0 = don't swap lcd output pixel data  1 = swap lcd output pixel data" "0,1"
        textline "                                "
        bitfld.long 0x00 0. "CFG_SPLIT_EN              ,split mode enable, this bit should be set as same as lcd split mode  0 =  split mode disable, just dsia is used for display   1 = split mode enable, both dsia and dsib are used for display" "0,1"

group d:0xD4238088++0x03
    line.long 0x00 "DSI_LCD_BDG_CTRL1,DSI LCD Bridge Control Register 1"
        hexmask.long.word 0x00 16.--31. 1. " CFG_CPN_TE_DLY_CNT        ,cpn tearing effect delay count, the lcd output pixel data will delay cfg_cpn_te_dly_cnt cycles after te pulse"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_CPN_TE_LINE_CNT       ,cpn tearing effect line count, when te_mode = 2, this field will take effect. the lcd output pixel data will wait for cfg_cpn_te_line_cnt te pulse"

group d:0xD42380E4++0x03
    line.long 0x00 "DSI_TX_TIMER,DSI TX Timer Register"
        hexmask.long 0x00 0.--31. 1. " CFG_TX_TIMER_CNT          ,tx transmission timer value  this timer monitors the tx operation on the dsi output side. it could generate irq after timer timeout. by default setting, timeout will not happen because the reset value is the maximum value (0xffffffff)."

group d:0xD42380E8++0x03
    line.long 0x00 "DSI_RX_TIMER,DSI RX Timer Register"
        hexmask.long 0x00 0.--31. 1. " CFG_RX_TIMER_CNT          ,rx timer value  this timer monitors the rx operation on the dsi operation. it could generate irq after timer timeout. by default setting, timeout will not happen because the reset value is the maximum value (0xffffffff)."

group d:0xD42380EC++0x03
    line.long 0x00 "DSI_TURN_TIMER,DSI Turn Around Timer Register"
        hexmask.long 0x00 0.--31. 1. " CFG_TURN_TIMER_CNT        ,bus turn around timer value  this timer monitors the turn around operation on the dsi. it could generate irq after timer timeout. by default setting, timeout will not happen because the reset value is the maximum value (0xffffffff)."

group d:0xD4238100++0x03
    line.long 0x00 "DSI_VPN_CTRL_0,DSI Video Panel  Control Register 0"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_DLY_CNT           ,vpn vsync delay count in slave mode. in slave mode, dsi will start h/v timing depending on input vsync timing from lcd module.   in slave mode, after dsi receives a vsync from lcd controller, it will start a vsync timing by delaying this count of clock."
        hexmask.long.byte 0x00 0.--7. 1. "      CFG_VPN_TX_DLY_CNT        ,vpn tx delay count  after dsi starts a hsync timing, delay this count of dphy byte clock count to start a vss packet transfer. this is a dsi internal delay to guarantee a fixed tx timing at dphy interface."

group d:0xD4238104++0x03
    line.long 0x00 "DSI_VPN_CTRL_1,DSI Video Panel Control Register 1"
        bitfld.long 0x00 31. " CFG_VPN_VSYNC_RST_EN      ,lcd vsync reset enable in slave mode  1 = reset dsi vertical state machine when lcd vsync comes. this will only take effect when lcd is in slave mode.  0 = don't reset dsi vertical state machine" "0,1"
        bitfld.long 0x00 27. "         CFG_VPN_AUTO_WC_DIS       ,vpn auto word count disable  this bit has lower priority than cfg_vpn_hact_wc_en  0x0 = enable auto word count calculation, and hardware automatically calculates how many bytes will be sent in each h line slot  0x1 = auto word count calculation will not be effective" "0,1"
        bitfld.long 0x00 26. "     CFG_VPN_HACT_WC_EN       ,vpn hact word count enable  this bit has higher priority than cfg_vpn_auto_wc_en  0x0 = cfg_hact_wc will not be effective if cfg_vpn_auto_wc_dis is 0  0x1 = enable hact word count parameter, and cfg_hact_wc will be used to decide how many bytes are sent" "0,1"
        bitfld.long 0x00 25. "       CFG_VPN_TIMING_CHECK_DIS  ,vpn hss/hse/hact tx timing check disable  0x0 = check timing before requesting dphy for tx  0x1 = don't check timing before requesting dphy for tx" "0,1"
        textline "                                "
        bitfld.long 0x00 24. "CFG_VPN_AUTO_DLY_DIS      ,vpn auto vsync delay count disable  0x0 = enable auto vsync delay count calculation, and hardware will automatically use halt of cfg_htotal_cnt to replace cfg_vpn_dly_cnt  0x1 = auto vsync delay count disabled, hardware will use the cfg_vpn_dly_cnt for vsync delay" "0,1"
        bitfld.long 0x00 22. "         CFG_VPN_HLP_PKT_EN        ,long blanking packet enable  1 = dsi will send out a long blanking packet during hlp time slot  0 = long blanking packet is disabled, dsi will go to low power during this time slot  in most cases, this field should be programmed to 0x0." "0,1"
        bitfld.long 0x00 21. "     CFG_VPN_HEX_PKT_EN       ,extra long blanking packet enable  1 = dsi will send out a long blanking packet after pixel data transmission and before hfp  0 = extra long blanking packet is disabled, dsi will go to low power during this time slot  in most cases, this field should be programmed to 0x0." "0,1"
        bitfld.long 0x00 20. "       CFG_VPN_HFP_PKT_EN        ,front porch packet enable  1 = dsi will send out a long blanking packet during hfp time slot  0 = hfp long blanking packet is disabled, dsi will go to low power during this time slot  if front porch period is not long enough for dphy to go to low power state and come back to hs again timely for next hss packet, this field should be programmed to 0x1." "0,1"
        textline "                                "
        bitfld.long 0x00 18. "CFG_VPN_HBP_PKT_EN        ,back porch packet enable  1 = dsi will send out a long blanking packet during hbp time slot  0 = hbp long blanking packet is disabled, dsi will go to low power during this time slot  if back porch period is not long enough for dphy to go to low power state and come back to hs again timely for next pixel data packet, this field should be programmed to 0x1." "0,1"
        bitfld.long 0x00 17. "         CFG_VPN_HSE_PKT_EN        ,hse packet enable  1 = dsi will send out hse packet during hbp time slot  0 = hse packet is disabled, dsi will go to low power during this time slot  enable this bit when transmission mode is in non-burst mode with sync pulse." "0,1"
        bitfld.long 0x00 16. "     CFG_VPN_HSA_PKT_EN       ,hsa packet enable  1 = dsi will send out hsa long blanking packet during hbp time slot  0 = hsa packet is disabled, dsi will go to low power during this time slot  if transmission mode is non-burst mode with sync event or burst mode, this field should be disabled. if transmission mode is non-burst mode with sync pulse, this field can be programmed to 0x1." "0,1"
        bitfld.long 0x00 14. "       CFG_VPN_HEX_SLOT_EN       ,extra long packet enable after pixel data  1 = enable extra long packet after pixel data transfer, this will insert a long blanking packet before hfp  0 = no extra long packet is inserted after pixel data transfer  this field takes effect only in burst mode.  in most cases, this field should be programmed to 0x0." "0,1"
        textline "                                "
        bitfld.long 0x00 10. "CFG_VPN_LAST_LINE_TURN    ,turn around bus at last h line  1 = dsi will turn around the bus every frame during the last h line, this will request slave to return an acknowledge or acknowledge with error  0 = dsi will not turn around the bus during the last h line  in most cases, this field should be programmed to 0x0." "0,1"
        bitfld.long 0x00 9. "         CFG_VPN_LPM_FRAME_EN      ,go to low power every frame  1 = dsi will go to low power mode every frame during the last h line  0 = dsi will not go to low power mode during the last h line  in most cases, this field should be programmed to 0x0." "0,1"
        bitfld.long 0x00 2.--3. "     CFG_VPN_BURST_MODE       ,dsi transmission mode for lcd 1  0x0 = non-burst mode with sync pulse  0x1 = non-burst mode with sync event  0x2 = burst mode" "0,1,2,3"
        bitfld.long 0x00 0.--1. "       CFG_VPN_RGB_TYPE          ,lcd 1 input data rgb mode for lcd 1  0x0 = 565 rgb mode  0x1 = 666 packet mode  0x2 = 666 un-packet mode  0x3 = 888 rgb mode" "0,1,2,3"

group d:0xD4238110++0x03
    line.long 0x00 "DSI_VPN_TIMING_0,DSI Video Panel Timing Register 0"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_HACT_CNT          ,vpn hact clock count in byte clock domain. this parameter defines the byte clock cycle numbers for horizontal line pixel data period    the data byte number for this period is hact_byte_cnt = hact_cnt*lane_num"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_HTOTAL_CNT        ,vpn htotal clock count in byte clock domain. this parameter defines the byte clock cycle numbers for horizontal line period    the data byte number for this period is htotal_byte_cnt = htotal_cnt*lane_num"

group d:0xD4238114++0x03
    line.long 0x00 "DSI_VPN_TIMING_1,DSI Video Panel Timing Register 1"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_HSYNC_CNT         ,vpn hsync clock count in byte clock domain. this parameter defines the byte clock cycle numbers for horizontal line hsync period    the data byte number for this period is hsync_byte_cnt = hsync_cnt*lane_num"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_HBP_CNT           ,vpn hbp clock count in byte clock domain. this parameter defines the byte clock cycle numbers for horizontal line back porch period    the data byte number for this period is hbp_byte_cnt = hbp_cnt*lane_num    front porch clock count can be calculated by: hfp_cnt = htotal_cnt - hsync_cnt - hact_cnt - hbp_cnt    the data byte number for front porch period is hfp_byte_cnt = hfp_cnt*lane_num"

group d:0xD4238118++0x03
    line.long 0x00 "DSI_VPN_TIMING_2,DSI Video Panel Timing Register 2"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_VACT_CNT          ,vpn vact line count"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_VTOTAL_CNT        ,vpn vtotal line count"

group d:0xD423811C++0x03
    line.long 0x00 "DSI_VPN_TIMING_3,DSI Video Panel Timing Register 3"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_VSYNC_CNT         ,vpn vsync line count"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_VBP_CNT           ,vpn vbp line count"

group d:0xD4238120++0x03
    line.long 0x00 "DSI_VPN_WC_0,DSI Video Panel Word Count Register 0"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_HBP_WC            ,vpn hbp packet payload data byte count  this parameter must be programmed if hbp_pkt_en is 0x1, otherwise it can be kept as 0x0   if transmission mode is non-burst mode with sync pulse, hbp_wc = hbp_byte_cnt - hse_byte_cnt(4) - hbp_pkt_overhead(6)  if transmission mode is non-burst mode with sync event or burst mode, hbp_wc = hsync_byte_cnt + hbp_byte_cnt - hss_byte_cnt(4) - hbp_pkt_overhead(6)"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_HSA_WC            ,vpn hsa packet payload data byte count  this parameter must be programmed if hsa_pkt_en is 0x1, otherwise it can be kept as 0x0   if transmission mode is non-burst mode with sync pulse, hsa_wc = hsync_byte_cnt - hss_byte_cnt(4) - hsa_pkt_overhead(6), otherwise it is 0x0"

group d:0xD4238124++0x03
    line.long 0x00 "DSI_VPN_WC_1,DSI Video Panel Word Count Register 1"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_HFP_WC            ,vpn hfp packet payload data byte count  this parameter must be programmed if hfp_pkt_en is 0x1, otherwise it can be kept as 0x0   if transmission mode is non-burst mode with sync pulse, or non-burst mode with sync event, hfp_wc = hfp_byte_cnt - hact_pkt_overhead(6) - hfp_pkt_overhead(6)   if transmission mode is burst mode and hex_pkt_en = 1, hfp_wc = hfp_byte_cnt - hact_pkt_overhead(6) - hfp_pkt_overhead(6)   if transmission mode is burst mode and hex_pkt_en = 0, hfp_wc = hfp_byte_cnt + (hact_byte_cnt - hact_wc) - hact_pkt_overhead(6) - hfp_pkt_overhead(6)"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_HACT_WC           ,vpn hact packet payload data byte count    this parameter is equal to active pixel rgb data total byte count"

group d:0xD4238128++0x03
    line.long 0x00 "DSI_VPN_WC_2,DSI Video Panel Word Count Register 2"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_HEX_WC            ,vpn hex packet payload data byte count  this parameter must be programmed if hex_pkt_en is 0x1, otherwise it can be kept as 0x0   if transmission mode is burst mode, hex_wc = hact_byte_cnt - hact_wc - hex_pkt_overhead(6)   otherwise hex_wc = 0"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_HLP_WC            ,vpn hlp packet payload data byte count  this parameter must be programmed if hlp_pkt_en is 0x1, otherwise it can be kept as 0x0   if transmission mode is non-burst mode with sync pulse, hlp_wc = htotal_byte_cnt - hsync_byte_cnt - hse_byte_cnt(4) - hlp_pkt_overhead(6)   if transmission mode is non-burst mode with sync event or burst mode, hlp_wc = htotal_byte_cnt - hss_byte_cnt(4) - hlp_pkt_overhead(6)"

group d:0xD4238130++0x03
    line.long 0x00 "DSI_VPN_SLOT_CNT_0,DSI Video Panel Time Slot Count 0 Register"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_SLOT_SP_CNT       ,vpn time slot count for short packet. this parameter defines a min slot period for short packet transmission, which should ensure dphy can go to low power, send the short packet, and return to hs again in time for next active panel packet which has a strict timing requirement.   if any dsi active panel data flow is working, and cpu or smart interface wants to send short packet between the active panel packets, the internal state machine will try to find a time slot between active panel packets which has a larger period than the defined value. dsi will only send cpu or command panel short packet during such slot to ensure dphy has enough time to go to low power, send the packet, and return to hs again in time for next active panel packet which has a strict timing requirement.  the programming of his parameter is necessary only when multiple panels or data paths are working simultaneously."
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_SLOT_LP_CNT       ,vpn time slot count for long packet. this parameter defines a min slot period for long packet transmission, which should ensure dphy can go to low power, send the long packet, and return to hs again in time for next active panel packet which has a strict timing requirement.   the programming of his parameter is necessary only when multiple panels or data paths are working simultaneously."

group d:0xD4238134++0x03
    line.long 0x00 "DSI_VPN_SLOT_CNT_1,DSI Video Panel Time Slot Count 1"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_SLOT_TXLP_CNT     ,vpn time slot count for low power packet tx. this parameter defines a min slot period for low power packet transmission, which should ensure dphy can go to low power, send the low power packet, and return to hs again in time for next active panel packet which has a strict timing requirement.   the programming of his parameter is necessary only when multiple panels or data paths are working simultaneously."
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_SLOT_TN_CNT       ,vpn time slot count for bus turn around. this parameter defines a min slot period for short packet transmission, which should ensure dphy can go to low power, turn around the bus, and return to hs again in time for next active panel packet which has a strict timing requirement."

group d:0xD4238138++0x03
    line.long 0x00 "DSI_VPN_SYNC_CODE,DSI Video Panel Sync Code"

group d:0xD4238140++0x03
    line.long 0x00 "DSI_VPN_STATUS_0,DSI VPN Status Register 0"
        bitfld.long 0x00 31. " CFG_VPN_RD_ERR            ,vpn input buffer read error. this includes cfg_vpn_rd_2early, cfg_vpn_line_miss, and cfg_vpn_rd_underrun." "0,1"
        bitfld.long 0x00 30. "         CFG_VPN_LINE_MISS         ,vpn input buffer line miss. this indicates a whole h line pixel data missed." "0,1"
        bitfld.long 0x00 29. "     CFG_VPN_RD_2EARLY        ,vpn input buffer read too early" "0,1"
        bitfld.long 0x00 28. "       CFG_VPN_RD_UNDERRUN       ,vpn input buffer underrun" "0,1"
        textline "                                "
        bitfld.long 0x00 27. "CFG_VPN_BF_FULL           ,vpn input buffer full" "0,1"
        bitfld.long 0x00 26. "         CFG_VPN_RD_DELAY_ERR      ,vpn request delay error at arbiter" "0,1"
        hexmask.long.tbyte 0x00 0.--20. 1. "     CFG_VPN_STATUS_0         ,dsi vpn status register for debug purpose   {l1_lcd[4:0]_cs, l1_vst[6:0], l1_hst[8:0]}"

group d:0xD4238144++0x03
    line.long 0x00 "DSI_VPN_STATUS_1,DSI VPN Status Register 1"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_WRDONE_RDDONE_CNT ,vpn input buffer write done to input buffer read done clock count. this could help to tune the vsync delay count."
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_WR2RD_CNT         ,vpn input buffer write to input buffer read clock count. this could help to tune the vsync delay count."

group d:0xD4238148++0x03
    line.long 0x00 "DSI_VPN_STATUS_2,DSI VPN Status Register 2"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_UNDERRUN_CNT      ,vpn input buffer underrun count"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_RD_DATWR_CNT      ,vpn input buffer read to data write count"

group d:0xD423814C++0x03
    line.long 0x00 "DSI_VPN_STATUS_3,DSI VPN Status Register 3"
        hexmask.long.word 0x00 16.--31. 1. " CFG_VPN_REQ_ARB_DLY_CNT   ,vpn tx req delay count at arbiter interface"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_VPN_REQ_PHY_DLY_CNT   ,vpn tx req delay count at dphy interface"

group d:0xD4238150++0x03
    line.long 0x00 "DSI_VPN_STATUS_4,DSI VPN Status Register 4"
        hexmask.long 0x00 0.--31. 1. " CFG_VPN_FRM_CNT           ,dsi vpn tx frame count"

group d:0xD4238180++0x03
    line.long 0x00 "DSI_PHY_CTRL_0,DPHY Control Register 0"
        bitfld.long 0x00 31. " CFG_RX_TRG_REG_DIS        ,disable register for low power rx trigger signals. internal use." "0,1"
        bitfld.long 0x00 30. "         CFG_TX_LANE_0             ,new packet tx start from lane 0  =0 if two packets are transferred continuously, all data are packed and distributed to all enabled lanes the second packet could start from any lane  1 = transmission of every new packet starts from lane 0 if two packets are transferred continuously, and the first packet doesn't occupy all lanes, then extra byte of 0 will be inserted in at the end of first packet to ensure the second packet start from lane 0 this is an debug option and should be set to 0" "0,1"
        bitfld.long 0x00 27. "     CFG_FCLK_NOT             ,reverse the input byte clk from dphy to dsi control logic. the output data to dphy should be valid at falling edge of byte clk." "0,1"
        hexmask.long.byte 0x00 16.--23. 1. "       CFG_STOP_ST_CNT           ,dphy stop state count. for txlp and phy control"
        textline "                                "
        hexmask.long.byte 0x00 8.--15. 1. "CFG_RX_DLY_CNT            ,dphy rx_delay count. for rx control"

group d:0xD4238184++0x03
    line.long 0x00 "DSI_PHY_CTRL_1,DPHY Control Register 1"
        bitfld.long 0x00 17. " CFG_VDD_ANA_VALID         ,dphy analog vdd valid" "0,1"
        bitfld.long 0x00 16. "         CFG_VDD_DVM_VALID         ,dphy digital vdd valid" "0,1"
        bitfld.long 0x00 2. "     CFG_ULPS_REQ_BYTE        ,dphy all lane force to ulps" "0,1"
        bitfld.long 0x00 1. "       CFG_TX_ULPS_CLK_ESC       ,dphy clk lane force to ulps" "0,1"
        textline "                                "
        bitfld.long 0x00 0. "CFG_CONT_CLK_HS           ,dphy clock lane continuous clocking in hs" "0,1"

group d:0xD4238188++0x03
    line.long 0x00 "DSI_PHY_CTRL_2,DPHY Control Register 2"
        bitfld.long 0x00 14. " CFG_CSR_HSTX_RX_EN        ,rx enable when dphy hstx   0x0 = disable   0x1 enable" "0,1"
        bitfld.long 0x00 12.--13. "         CFG_CSR_LANE_MAP          ,dphy data map to lane order   0x0 = lane0, lane1, lane2, lane3    0x1 = lane0,  lane3, lane1, lane2    0x2 = lane0, lane2, lane3, lane1    = 0x3 reserved." "0,1,2,3"
        bitfld.long 0x00 8.--11. "     CFG_CSR_LANE_RESC_EN     ,dphy lp receiver enable  enable the reverse escape lp receiver. lane immediately transmits to receive mode." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "      CFG_CSR_LANE_EN           ,dphy data lane enable" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                "
        bitfld.long 0x00 0.--3. "CFG_CSR_LANE_TURN         ,dphy bus turn around  this field indicates that the protocol desires to turn the lane around, allowing the other side to begin transmitting." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD423818C++0x03
    line.long 0x00 "DSI_PHY_CTRL_3,DPHY Control Register 3"
        bitfld.long 0x00 9. " CFG_FORCECLK_HIZ_HS       ,dphy clk lane force to high-z in hs mode" "0,1"
        bitfld.long 0x00 8. "         CFG_FORCECLK_HIZ_LP       ,dphy clk lane force to high-z in lp mode" "0,1"
        bitfld.long 0x00 4.--7. "     CFG_FORCE_HIZ_HS         ,dphy force data lane to high-z in hs mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "      CFG_FORCE_HIZ_LP          ,dphy data lane force to high-z in lp mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4238190++0x03
    line.long 0x00 "DSI_PHY_STATUS_0,DPHY Status Register 0"
        bitfld.long 0x00 28.--31. " DPHY_RDY_HS_BYTE          ,dphy hs tx ready signals" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "        TX_REQ_HS_BYTE            ,dphy hs tx request signals" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "    DPHY_LANE_RX_LINE_ERR653 ,ppi errcontrol  illegal line state detected" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "      DPHY_ERR_SYNC_ESC654      ,ppi errsyncesc  partial byte detected" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                "
        bitfld.long 0x00 8.--11. "DPHY_ERR_ESC655           ,ppi erresc  invalid esc command detected" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "        DPHY_ERR_CONT_LP0656      ,ppi errcontentionlp0  contention detect" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "    DPHY_ERR_CONT_LP1657     ,ppi errcontentionlp0  contention detect" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4238194++0x03
    line.long 0x00 "DSI_PHY_STATUS_1,DPHY Status Register 1"
        bitfld.long 0x00 31. " DPHY_ULP_STATE_BYTE       ,all lanes are ulps" "0,1"
        bitfld.long 0x00 30. "         DPHY_STOP_STATE_BYTE      ,ppi stopstate - all lanes in stop state" "0,1"
        bitfld.long 0x00 29. "     DPHY_CLK_ULPS_ACTIVE_N   ,ppi clock ulpsactivenot" "0,1"
        bitfld.long 0x00 28. "       DPHY_RX_CLK_ULPS_N        ,ppi rxulpsclknot" "0,1"
        textline "                                "
        bitfld.long 0x00 24.--27. "DPHY_LANE_DIR             ,ppi direction" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "        DPHY_ULPS_ACTIVE_N        ,ppi ulpsactivenot" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "    DPHY_LANE_RX_LINE_ERR670 ,ppi errcontrol - illegal line state detected." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "      DPHY_ERR_ESC671           ,ppi erresc - invalid esc command detected" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                "
        bitfld.long 0x00 8.--11. "DPHY_ERR_SYNC_ESC672      ,ppi errsyncesc - partial byte detected" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "        DPHY_ERR_CONT_LP0673      ,ppi errcontentionlp0 - contention detect" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "    DPHY_ERR_CONT_LP1674     ,ppi errcontentionlp0 - contention detect" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4238198++0x03
    line.long 0x00 "DSI_PHY_LPRX_0,DPHY LP RX Register 0"
        bitfld.long 0x00 28.--31. " DPHY_LANE_RX_TRG3         ,dphy_lane_rx_trg3" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "        DPHY_LANE_RX_TRG2         ,dphy_lane_rx_trg2" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "    DPHY_LANE_RX_TRG1        ,dphy_lane_rx_trg1" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "      DPHY_LANE_RX_TRG0         ,dphy_lane_rx_trg0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                "
        bitfld.long 0x00 12.--15. "DPHY_LANE_RX_ULPS         ,dphy_lane_rx_ulps" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "        DPHY_LANE_RX_LPDT         ,dphy_lane_rx_lpdt" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "    DPHY_LANE_RX_DVALID      ,dphy_lane_rx_dvalid" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "      DPHY_LANE_RX_CLK          ,dphy_lane_rx_clk" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD423819C++0x03
    line.long 0x00 "DSI_PHY_LPRX_1,DPHY LP RX Register 1"
        hexmask.long 0x00 0.--31. 1. " DPHY_LANE_DOUT_RX         ,dphy_lane_dout_rx"

group d:0xD42381A0++0x03
    line.long 0x00 "DSI_PHY_LPTX_0,DPHY LP TX Register 0"
        hexmask.long.word 0x00 20.--31. 1. " DPHY_TX_TRIGGER_ESC_L     ,tx_trigger_esc[11:0]"
        bitfld.long 0x00 16.--19. "      DPHY_TX_ULPS_ESC          ,tx_ulps_esc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 12.--15. "    DPHY_TX_LPDT_ESC         ,tx_lpdt_esc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "      DPHY_TX_VALID_ESC         ,tx_valid_esc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                "
        bitfld.long 0x00 4.--7. "DPHY_TX_REQ_ESC           ,tx_req_esc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "        DPHY_LANE_RDY_ESC         ,dphy_lane_rdy_esc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD42381A4++0x03
    line.long 0x00 "DSI_PHY_LPTX_1,DPHY LP TX Register 1"
        bitfld.long 0x00 0.--3. " DPHY_TX_TRIGGER_ESC_H     ,tx_trigger_esc[15:12]" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD42381A8++0x03
    line.long 0x00 "DSI_PHY_LPTX_2,DPHY LP TX Register 2"
        hexmask.long 0x00 0.--31. 1. " DPHY_TX_DATA_ESC          ,tx_data_esc"

group d:0xD42381AC++0x03
    line.long 0x00 "DSI_PHY_STATUS_2,DPHY Status Register 2"
        hexmask.long.word 0x00 16.--31. 1. " CFG_TX_REQ_CNT_R          ,tx previous req to rdy delay count"
        hexmask.long.word 0x00 0.--15. 1. "      CFG_TX_REQ_CNT            ,tx req to rdy delay count"

group d:0xD42381C0++0x03
    line.long 0x00 "DSI_PHY_TIME_0,DPHY Timing Control Register 0"
        hexmask.long.byte 0x00 24.--31. 1. " CFG_CSR_TIME_HS_EXIT      ,length of hs exit period in tx_clk_esc cycles  this field is used for the time to drive lp-11 after hs burst.  hs exit period = (1+cfg_csr_hs_exit)/66 mhz  by default, dphy esc clock frequency is 66 mhz  from mipi spec, the minimum value is 100 ns."
        hexmask.long.byte 0x00 16.--23. 1. "        CFG_CSR_TIME_HS_TRAIL     ,dphy hs trail period length  this field is used for the time to drive flipped differential state after the last payload data bit of a hs transmission burst.  length of hs trail period is in tx_clk_esc cycles.  hs trail time = (1 + cfg_csr_hs_trail)/66 mhz  from mipi spec, the minimum value is defined by max (8*ui, 60 ns + 4*ui)."
        hexmask.long.byte 0x00 8.--15. 1. "    CDG_CSR_TIME_HS_ZERO     ,dphy hs zero state length  this field is used for the time to drive hs-0 before the sync sequence.  length of hs zero state is in tx_clk_esc cycles.  hs zero state length >= (cfg_csr_time_zero - 2)/66 mhz + 3*tbyte_clk   from mipi spec, the minimum value for (time hs prep + time hs zero) is 145 ns + 10*ui."
        hexmask.long.byte 0x00 0.--7. 1. "      CFG_CSR_TIME_HS_PREP      ,dphy hs prepare state length  this field is used for the time to drive lp-00 to prepare for hs transmission.   it is the length of hs prepare state period in tx_clk_esc cycles.  time hs prep = (1+ cfg_csr_time_hs_prep)/66 mhz  from mipi specification for dphy, the minimum value for this parameter is 40 ns + 4*ui, and the maximum value is 85 ns_6*ui."

group d:0xD42381C4++0x03
    line.long 0x00 "DSI_PHY_TIME_1,DPHY Timing Control Register 1"
        hexmask.long.byte 0x00 24.--31. 1. " CFG_CSR_TIME_TA_GET       ,time to drive lp-00 by new transmitter in tx_clk_esc cycles  ta get time = (1 + cfg_csr_time_ta_get)/66 mhz  from mipi spec, the typical value is 5*tlpx, where tlpx is dphy lp length: tlpx = (1 + cfg_csr_time_lpx)/66 mhz"
        hexmask.long.byte 0x00 16.--23. 1. "        CFG_CSR_TIME_TA_GO        ,time to drive lp-00 after turn request in tx_clk_esc cycles  ta go time = (1 + ta_go)/66 mhz  from mipi spec, the typical value is 4*tlpx."
        hexmask.long.word 0x00 0.--15. 1. "    CFG_CSR_TIME_WAKEUP      ,dphy hs wakeup period length  this field is the recovery time from ultra-low power state (ulps).  twakeup = (1 + cfg_csr_time_wakeup)/66 mhz  from mipi spec, the minimum value is 1 ms."

group d:0xD42381C8++0x03
    line.long 0x00 "DSI_PHY_TIME_2,DPHY Timing Control Register 2"
        hexmask.long.byte 0x00 24.--31. 1. " CFG_CSR_TIME_CK_EXIT      ,dphy clk exit period length in tx_clk_esc cycles  tck_exit = (1 + cfg_csr_time_ck_exit)/66 mhz  this field should use the same value as cfg_csr_time_hs_exit"
        hexmask.long.byte 0x00 16.--23. 1. "        CFG_CSR_TIME_CK_TRAIL     ,dphy clk trail period length in tx_clk_esc cycles  this field is the time to drive hs differential state after the last payload clock bit of a hs transmission burst.  clk trail time = (1 + cfg_csr_time_ck_trail)/66 mhz  from mipi spec, the minimum value is 60 ns."
        hexmask.long.byte 0x00 8.--15. 1. "    CFG_CSR_TIME_CK_ZERO     ,dphy clk zero state length in tx_clk_esc cycles  this field is the time for lead hs-0 drive period before starting the clock.  tck_zero = (1 + cfg_csr_time_ck_zero)/66 mhz  from mipi spec, the minimum value for (tck_prep+tck_zero) is 300 ns, where in <var product number> tck_prep is the same as time hs prep defined by cfg_cst_time_hs_prep."
        hexmask.long.byte 0x00 0.--7. 1. "      CFG_CSR_TIME_CK_LPX       ,dphy clk lp length  this field is the length of clk low power state period in tx_clk_esc cycles.  clk lpx time = tck_lpx = (1 + cfg_csr_time_ck_lpx) / 66 mhz  this field should be set to the same value as cfg_cst_time_lpx."

group d:0xD42381CC++0x03
    line.long 0x00 "DSI_PHY_TIME_3,DPHY Timing Control Register 3"
        hexmask.long.byte 0x00 8.--15. 1. " CFG_CSR_TIME_LPX          ,dphy lp length  this field is the length of any low power state period in tx_clk_esc cycles.  lpx time = tlpx = (1 + cfg_csr_time_lpx) / 66 mhz  from mipi spec, the minimum value is 50 ns."
        hexmask.long.byte 0x00 0.--7. 1. "        CFG_CSR_TIME_REQRDY       ,dphy hs req to rdy length  this field is the minimum byte clock cycles of dsi hs tx request to dphy ready.  sometimes it may be important for this length to be consistent to maintain precise vertical and horizontal timing. in most cases, this parameter should be kept at the default of 0x0.  total cycles between dsi hs tx request to dphy ready is composed by dphy <q>clock lane timing,</q> <q>gap,</q> <q>data lane timing</q> and some other items inside dphy.   clock lane timing = (2*(cfg_csr_time_ck_lpx + 1) + (cfg_csr_time_hs_prep + 1) + (cfg_csr_time_ck_zero + 1))/66 mhz   gap = (16ui +2)/66 mhz  data lane timing = ((2*cfg_csr_time_lpx + 1) + (cfg_csr_time_hs_prep + 1) + (cfg_csr_time_hs_zero + 1))/66 mhz    (1 + cfg_csr_time_reqrdy)/frequecy_byte_clk = (clock lane timing + gap + data lane timing + 10/66 mhz)   one other way to get a value for this parameter is to after dsi active panel data flow is running, read back the value of register dsi_phy_status_2 (0x1ac). bits [7:0] of this register is the current clock cycle value of delay between dsi tx request and dphy ready. add 2 to this value and program it to cfg_csr_time_reqrdy."

group d:0xD42381D0++0x03
    line.long 0x00 "DSI_PHY_CODE_0,DPHY CODE Register 0"
        hexmask.long.byte 0x00 24.--31. 1. " CFG_TRIG3_CODE            ,dphy trigger 3 code"
        hexmask.long.byte 0x00 16.--23. 1. "        CFG_TRIG2_CODE            ,dphy trigger 2 code"
        hexmask.long.byte 0x00 8.--15. 1. "    CFG_TRIG1_CODE           ,dphy trigger 1 code"
        hexmask.long.byte 0x00 0.--7. 1. "      CFG_TRIG0_CODE            ,dphy trigger 0 code"

group d:0xD42381D4++0x03
    line.long 0x00 "DSI_PHY_CODE_1,DPHY CODE Register 1"
        hexmask.long.byte 0x00 24.--31. 1. " CFG_CSR_ULPS_CODE         ,dphy ultra low power code"
        hexmask.long.byte 0x00 16.--23. 1. "        CFG_CSR_LPDT_CODE         ,dphy low power data transfer code"

group d:0xD42381E0++0x03
    line.long 0x00 "DSI_PHY_ANA_PWR_CTRL,DPHY ANALOG POWER Controller Register"
        bitfld.long 0x00 8. " CFG_DPHY_ANA_RESETB       ,dphy analog reset  0 = reaset dphy analog   1= de-reset dphy analog" "0,1"
        bitfld.long 0x00 0. "         CFG_DPHY_ANA_PU           ,dphy analog power up  0 = power down dphy analog  1= power up dphy analog" "0,1"

group d:0xD42381E4++0x03
    line.long 0x00 "DSI_PHY_ANA_CTRL0,DPHY ANALOG Controller Register 0"
        bitfld.long 0x00 29.--31. " CFG_DPHY_LPRX_VTTH        ,lprx reference voltage high  000: 760mv …..  20mv per stage 010: 800mv 111: 900 mv" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 26.--28. "         CFG_DPHY_LPRX_VTHL        ,lprx reference voltage low 000: 540mv …..  20mv per stage 010:580mv 011:600mv 111: 680 mv" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 24.--25. "     CFG_DPHY_LPTX_RES        ,lptx driver impedance control 000" "0,1,2,3"
        bitfld.long 0x00 21.--23. "       CFG_DPHY_HSTX_RES         ,hstx driver impedance control. 000: 120 ohm (differential @tt) 100: 100 ohm 111:  89   ohm" "0,1,2,3,4,5,6,7"
        textline "                                "
        bitfld.long 0x00 20. "CFG_DPHY_HSTX_LP          ,low power mode for hstx driver.   1 = lower power   0 = normal" "0,1"
        bitfld.long 0x00 17.--19. "         CFG_DPHY_ADJ_DLY_CK       ,adjust delay of ch_ck hstx driver output to manage skew between channels. 30ps (@tt) per stage. 000: 0 stage        111:  7 stages" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 16. "     CFG_DPHY_EN_CH_CK        ,enable for ch_ck.   when disabled, ch_ck is power down mode, pad_ckp and pad_ckn are in high-z mode  0 = disable  1 = enable" "0,1"
        bitfld.long 0x00 13.--15. "       CFG_DPHY_ADJ_DLY3         ,adjust delay of ch3 hstx driver output to manage skew between channels. 30ps (@tt) per stage. 000: 0 stage        111:  7 stages" "0,1,2,3,4,5,6,7"
        textline "                                "
        bitfld.long 0x00 12. "CFG_DPHY_EN_CH3           ,enable for ch3.   when disabled, ch3 is power down mode, pad_dn3 and pad_p3 are in high-z mode  0 = disable  1 = enable" "0,1"
        bitfld.long 0x00 9.--11. "         CFG_DPHY_ADJ_DLY2         ,adjust delay of ch2 hstx driver output to manage skew between channels. 30ps (@tt) per stage. 000: 0 stage        111:  7 stages" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 8. "     CFG_DPHY_EN_CH2          ,enable for ch2.   when disabled, ch2 is power down mode, pad_dn2 and pad_p2 are in high-z mode  0 = disable  1 = enable" "0,1"
        bitfld.long 0x00 5.--7. "       CFG_DPHY_ADJ_DLY1         ,adjust delay of ch1 hstx driver output to manage skew between channels. 30ps (@tt) per stage. 000: 0 stage        111:  7 stages" "0,1,2,3,4,5,6,7"
        textline "                                "
        bitfld.long 0x00 4. "CFG_DPHY_EN_CH1           ,enable for ch1.   when disabled, ch1 is power down mode, pad_dn1 and pad_p1 are in high-z mode  0 = disable  1 = enable" "0,1"
        bitfld.long 0x00 1.--3. "         CFG_DPHY_ADJ_DLY0         ,adjust delay of ch0 hstx driver output to manage skew between channels. 30ps (@tt) per stage. 000: 0 stage        111:  7 stages" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0. "     CFG_DPHY_EN_CH0          ,enable for ch0.   when disabled, ch0 is power down mode, pad_dn0 and pad_p0 are in high-z mode  0 = disable  1 = enable" "0,1"

group d:0xD42381E8++0x03
    line.long 0x00 "DSI_PHY_ANA_CTRL1,DPHY ANALOG Controller Register 1"
        bitfld.long 0x00 23. " CFG_CLK_SEL               ,dphy bit clk select    0 = pll_div2 output    1 = mipi_bit_clk mux output" "0,1"
        bitfld.long 0x00 20. "         CFG_SWAP_PN_CH3           ,swap pn polarity for ch3" "0,1"
        bitfld.long 0x00 19. "     CFG_SWAP_PN_CH2          ,swap pn polarity for ch2" "0,1"
        bitfld.long 0x00 18. "       CFG_SWAP_PN_CHCK          ,swap pn polarity for ch ck" "0,1"
        textline "                                "
        bitfld.long 0x00 17. "CFG_SWAP_PN_CH1           ,swap pn polarity for ch1" "0,1"
        bitfld.long 0x00 16. "         CFG_SWAP_PN_CH0           ,swap pn polarity for ch0" "0,1"
        bitfld.long 0x00 15. "     CFG_SET_TEST             ,select analog phy self-test 1: enable phy self-test. at this mode, phybypass all control signal 0: disable phy self-test." "0,1"
        bitfld.long 0x00 14. "       DFG_SET_TEST_LP           ,select lp or hs self-test mode. it only be valid when sel_test is high. 1: lp mode self test 0: hs mode self test" "0,1"
        textline "                                "
        bitfld.long 0x00 12.--13. "DFG_TEST_PATTERN          ,select self-test pattern generation 00: all 0 01: all 1 10: ck pattern (0101) 11: prbs7" "0,1,2,3"
        bitfld.long 0x00 11. "         CFG_EN_CLK_DIV2           ,enable half rate hstx mode. when enabled, phy will work at half data rate of pll input clock. 1: enable 0 disable" "0,1"
        bitfld.long 0x00 8.--10. "     CFG_DPHY_HSTX_VREF       ,hstx vreg control 000: 340mv …..  20mv per stage 011: 400mv 111: 480 mv" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 5.--7. "       CFG_DPHY_LPCDVTHH         ,lpcd reference voltage high  000: 300mv …..  20mv per stage 101:400mv 111: 440 mv" "0,1,2,3,4,5,6,7"
        textline "                                "
        bitfld.long 0x00 2.--4. "CFG_DPHY_LPCDVTHL         ,lpcd reference voltage low 000: 200mv …..  20mv per stage 010: 240mv 111: 340 mv" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 1. "         CFG_DPHY_PULL_DN          ,pull down enable: 1: enable pull down pad io for ch1,ch2,ch3,chck when both hstx and lptx are not enabled. 0: disable pull down pad io for ch1,ch2,ch3,chck when both hstx and lptx are not enabled. it's high z in this state." "0,1"
        bitfld.long 0x00 0. "     CFG_DPHY_PULL_DN_CH0     ,pull down enable for ch0 1: enable pull down pad io when all hstx, lptx and lprx are not enabled. 0: disable pull down  pad io when both hstx and lptx are not enabled. it's high z in this state." "0,1"

tree.end

tree "dro"

width 20.

group d:0xD4013200++0x03
    line.long 0x00 "DRO_CTRL,DRO monitor control register"
        bitfld.long 0x00 1. " INT_DRO          ," "0,1"
        bitfld.long 0x00 0. "         DRO_MONITOR_EN ," "0,1"

group d:0xD4013204++0x03
    line.long 0x00 "DRO_threshold_high,DRO threshold high addr"
        hexmask.long.word 0x00 0.--15. 1. " THRESHOLD_HIGH   ,"

group d:0xD4013208++0x03
    line.long 0x00 "DRO_threshold_low,DRO threshold low addr"
        hexmask.long.word 0x00 0.--15. 1. " THRESHOLD_LOW    ,"

group d:0xD401320C++0x03
    line.long 0x00 "DRO_tgl_cnt,DRO toggle CNT addr"
        hexmask.long.word 0x00 0.--15. 1. " DRO_RUNNING_TIME ,"

group d:0xD4013210++0x03
    line.long 0x00 "DRO_idle,DRO Idle time addr"
        hexmask.long 0x00 0.--31. 1. " IDLE_TIME        ,"

group d:0xD4013214++0x03
    line.long 0x00 "DRO_ring_cnt,DRO RING CNT addr"

group d:0xD4013218++0x03
    line.long 0x00 "DRO_cnt_ref,DRO CNT REF addr"

group d:0xD401321C++0x03
    line.long 0x00 "DRO_expt,DRO exception addr"

tree.end

tree "pmudvc"

width 15.

group d:0xD4052000++0x03
    line.long 0x00 "DVCR,Dynamic Voltage Change Control Register"
        bitfld.long 0x00 1. " VC_EN                         ,voltage change enable in active mode  1 = voltage change is allowed in active mode  0 = voltage change is not allowed" "0,1"
        bitfld.long 0x00 0. "     DV_LPM_AVC_EN16    ,automatic voltage change enable in low power mode  0 = automatic voltage change is disabled for every component  1 = automatic voltage change is enabled." "0,1"

group d:0xD4052020++0x03
    line.long 0x00 "DVC_AP,<var Processor: Application MP>  Dynamic Voltage Change Register"
        bitfld.long 0x00 28.--31. " C2_VL3:0                      ,cluster2 voltage level in active mode  required voltage level by <var processor: application mp> in m0/m1* mode  this voltage level can be dynamically changed due to a frequency change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "    PERI_VL3:0         ,peripheral voltage level in d0 active mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "  C1_VL3:0             ,cluster1 voltage level in active mode  required voltage level by <var processor: application mp> in m0/m1* mode  this voltage level can be dynamically changed due to a frequency change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 15. "  DV_VC_REQ27      ,voltage change request in active mode  voltage change request for <var processor: application mp> in m0/m1* power mode  software can write 1 to this bit to trigger a voltage change request. hardware will automaticly clear this bit when dvc is done. writes of 0 to this bit are ignored." "0,1"
        textline "                         "
        bitfld.long 0x00 8.--11. "C0_VL3:0                      ,cluster0 voltage level in active mode  required voltage level by <var processor: application mp> in m0/m1* mode  this voltage level can be dynamically changed due to a frequency change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7. "    C2_LPM_AVC_EN      ,cluster2 automatic voltage change enable in low power mode  this field is used for the <var processor: application mp>  0 = automatic voltage change is disabled  1 =  automatic voltage change is enabled  when <var processor: application mp> enters into m2* mode,  hardware automatically triggers a voltage change request." "0,1"
        bitfld.long 0x00 6. "   C1_LPM_AVC_EN        ,cluster1 automatic voltage change enable in low power mode  this field is used for the <var processor: application mp>  0 = automatic voltage change is disabled  1 =  automatic voltage change is enabled  when <var processor: application mp> enters into m2* mode,  hardware automatically triggers a voltage change request." "0,1"
        bitfld.long 0x00 5. "   C0_LPM_AVC_EN    ,cluster0 automatic voltage change enable in low power mode  this field is used for the <var processor: application mp>  0 = automatic voltage change is disabled  1 =  automatic voltage change is enabled  when <var processor: application mp> enters into m2* mode,  hardware automatically triggers a voltage change request." "0,1"
        textline "                         "
        bitfld.long 0x00 0.--3. "DV_LPM_VL3:034                ,required voltage level by <var processor: application mp> in m2* low power mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD405202C++0x03
    line.long 0x00 "DVC_APSUB,AP Subsystem Dynamic Voltage Change Register"
        bitfld.long 0x00 31. " UDR_AP_SLP_AVC_EN             ,automatic voltage change enable in udr ap_sleep mode(ap_d2 mode)  0 =  automatic voltage change is disabled  1 = automatic voltage change is enabled  when the ap subsystem enters into udr ap_sleep mode,  hardware automatically triggers a voltage change." "0,1"
        bitfld.long 0x00 24.--27. "     UDR_AP_SLP_VL      ,required voltage level in udr ap_sleep mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 23. "  NUDR_AP_SLP_AVC_EN   ,automatic voltage change enable in non-udr ap_sleep mode(ap_d1 mode)  0 =  automatic voltage change is disabled  1 = automatic voltage change is enabled  when the ap subsystem enters into non-udr ap_sleep mode,  hardware automatically triggers a voltage change." "0,1"
        bitfld.long 0x00 16.--19. "   NUDR_AP_SLP_VL   ,required voltage level in non-udr ap_sleep mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                         "
        bitfld.long 0x00 15. "AP_IDLE_DDROFF_AVC_EN         ,automatic voltage change enable in ap_idle_ddroff mode(ap_d1pp mode)  0 = automatic voltage change is disabled  1 = automatic voltage change is enabled  when the ap subsystem enters into ap_idle_ddroff mode,  hardware automatically triggers a voltage change request." "0,1"
        bitfld.long 0x00 8.--11. "     AP_IDLE_DDROFF_VL  ,required voltage level in ap_idle_ddroff mode( (ap_idle with ddr in self-refresh mode)" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7. "  AP_IDLE_DDRON_AVC_EN ,automatic voltage change enable in ap_idle_ddron mode(ap_d1p mode)  0 = automatic voltage change is disabled  1 = automatic voltage change is enabled  when the ap subsystem enters into ap_idle_ddron mode,  hardware automatically triggers a voltage change request." "0,1"
        bitfld.long 0x00 0.--3. "   AP_IDLE_DDRON_VL ,required voltage level in ap_idle_ddron mode (ap_idle with ddr on mode)" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4052030++0x03
    line.long 0x00 "DVC_CHIP,Chip Top Dynamic Voltage Change Register"
        bitfld.long 0x00 15. " UDR_SLP_AVC_EN                ,automatic voltage change enable in udr chip sleep mode(d2 mode) with vctcxo on  0 = automatic voltage change is disabled  1 = automatic voltage change is enabled  when udr chip sleep mode is entered,  hardware automatically triggers a voltage change request." "0,1"
        bitfld.long 0x00 8.--11. "     UDR_SLP_VL         ,required voltage level in udr chip sleep mode with vctcxo on" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7. "  NUDR_SLP_AVC_EN      ,automatic voltage change enable in non-udr chip sleep mode(d1 mode) with vctcxo on  0 = automatic voltage change is disabled  1 = automatic voltage change is enabled  when non-udr chip sleep mode is entered,  hardware automatically triggers a voltage change request." "0,1"
        bitfld.long 0x00 0.--3. "   NUDR_SLP_VL      ,required voltage level in non-udr chip sleep mode with vctcxo on" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4052040++0x03
    line.long 0x00 "DVC_STATUS,Dynamic Voltage Change Status Register"
        bitfld.long 0x00 24.--27. " DV_CAUSE73                    ,dvc cause  this field is the cause of the current ongoing dvc. it is only valid when the <dynamic voltage change status> field is 1.   0x1 = <var processor: application mp> software-triggered dvc   0x8 = hw-dfc triggered dvc <p>0x2=rsvd. <p>0x4=rsvd.   others = lpm entry/exit trigger dvc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "    DV_TVL3:075        ,target voltage level of vcc_main" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "  DV_CVL3:077          ,current voltage level of vcc_main" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0. "  DV_DVC_STATUS79  ,voltage change status  the voltage change may be triggered in active state or entering low power mode.  0 = there is no voltage change or a voltage change has finished  1 = voltage change is in progress" "0,1"

group d:0xD4052050++0x03
    line.long 0x00 "DVC_IMR, DVC Interrupt Mask Register"
        bitfld.long 0x00 0. " AP_VC_DONE_INTR_MASK          ,ap software triggered dvc done interrupt mask  1 = interrupt enabled  0 = interrupt disabled" "0,1"

group d:0xD4052054++0x03
    line.long 0x00 "DVC_ISR, DVC Interrupt Status Register"
        bitfld.long 0x00 0. " AP_VC_DONE_INTR_ISR           ,ap software triggered dvc done interrupt status   read 0 indicates no interrupt active. software write 0 to this bit to clear this interrupt  read 1 indicates interrupt is active. software write 1 has no effect to this bit's value" "0,1"

group d:0xD4052058++0x03
    line.long 0x00 "DVC_DEBUG, DVC Debug Register"
        bitfld.long 0x00 2. " TOP_REDUN_FUSE_LOAD_DONE_MASK ,top redundacy fuse load done check mask.   0x1=mask." "0,1"
        bitfld.long 0x00 1. "     CNT_DIS_FOR_VL_DWN ,enable/disable dvc stable timer counting when voltage change from high to low   0x0 = enabled   0x1 = disabled" "0,1"
        bitfld.long 0x00 0. "   M_DVC_CHECK_MASK     ,dvc check mask in main  state machine  0 = dvc status check is enabled  1 = dvc status check is masked" "0,1"

group d:0xD405205C++0x03
    line.long 0x00 "DVC_EXTRA_STR,DVC Extra Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " DVC_EXTRA_STR                 ,extra stable time needed for dvc except voltage ramp up time in vctcxo cycles."

group d:0xD4052060++0x03
    line.long 0x00 "VL01STR,Voltage Level 0 to Level 1 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL56_ST121                    ,voltage level 0 to level 1 stable time  this field determines the wait time for a voltage change from level 0 to level 1 in vctcxo cycles."

group d:0xD4052064++0x03
    line.long 0x00 "VL12STR,Voltage Level 1 to Level 2 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL56_ST130                    ,voltage level 1 to level 2 stable time  this field determines the wait time for a voltage change from level 1 to level 2 in vctcxo cycles."

group d:0xD4052068++0x03
    line.long 0x00 "VL23STR,Voltage Level 2 to Level 3 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL56_ST138                    ,voltage level 2 to level 3 stable time  this field determines the wait time for a voltage change from level 2 to level 3 in vctcxo cycles."

group d:0xD405206C++0x03
    line.long 0x00 "VL34STR,Voltage Level 3 to Level 4 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL56_ST147                    ,voltage level 3 to level 4 stable time  this field determines the wait time for a voltage change from level 3 to level 4 in vctcxo cycles."

group d:0xD4052070++0x03
    line.long 0x00 "VL45STR,Voltage Level 4 to Level  5 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL78_ST155                    ,voltage level 4 to level 5 stable time  this field determines the wait time for a voltage change from level 4 to level 5 in vctcxo cycles."

group d:0xD4052074++0x03
    line.long 0x00 "VL56STR,Voltage Level 5 to Level  6 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL78_ST163                    ,voltage level 5 to level 6 stable time  this field determines the wait time for a voltage change from level 5 to level 6 in vctcxo cycles."

group d:0xD4052078++0x03
    line.long 0x00 "VL67STR,Voltage Level 6 to Level  7 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL78_ST171                    ,voltage level 6 to level 7 stable time  this field determines the wait time for a voltage change from level 6 to level 7 in vctcxo cycles."

group d:0xD405207C++0x03
    line.long 0x00 "VL78STR,Voltage Level 7 to Level  8 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL78_ST179                    ,voltage level 7 to level 8 stable time  this field determines the wait time for a voltage change from level 7 to level 8 in vctcxo cycles."

group d:0xD4052080++0x03
    line.long 0x00 "VL89STR,Voltage Level 8 to Level 9 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL89_ST                       ,voltage level 8 to level 9 stable time  this field determines the wait time for a voltage change from level 8 to level 9 in vctcxo cycles."

group d:0xD4052084++0x03
    line.long 0x00 "VL910STR,Voltage Level 9 to Level  10 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL910_ST                      ,voltage level 9 to level 10 stable time  this field determines the wait time for a voltage change from level 9 to level 10 in vctcxo cycles."

group d:0xD4052088++0x03
    line.long 0x00 "VL1011STR,Voltage Level 10 to Level 11 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL1011_ST                     ,voltage level 10 to level 11 stable time  this field determines the wait time for a voltage change from level 10 to level 11 in vctcxo cycles."

group d:0xD405208C++0x03
    line.long 0x00 "VL1112STR,Voltage Level 11 to Level  12 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL1112_ST                     ,voltage level 11 to level 12 stable time  this field determines the wait time for a voltage change from level 11 to level 12 in vctcxo cycles."

group d:0xD4052090++0x03
    line.long 0x00 "VL1213STR,Voltage Level 12 to Level  13 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL1213_ST                     ,voltage level 12 to level 13 stable time  this field determines the wait time for a voltage change from level 12 to level 13 in vctcxo cycles."

group d:0xD4052094++0x03
    line.long 0x00 "VL1314STR,Voltage Level 13 to Level  14 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL1314_ST                     ,voltage level 13 to level 14 stable time  this field determines the wait time for a voltage change from level 13 to level 14 in vctcxo cycles."

group d:0xD4052098++0x03
    line.long 0x00 "VL1415STR,Voltage Level 14 to Level  15 Stable Time Register"
        hexmask.long.word 0x00 0.--15. 1. " VL1415_ST                     ,voltage level 14 to level 15 stable time  this field determines the wait time for a voltage change from level 14 to level 15 in vctcxo cycles."

tree.end

tree "pmumain"

width 16.

group d:0xD4050004++0x03
    line.long 0x00 "CPSR,Marvell Seagull/Mohawk Power Status Register"
        bitfld.long 0x00 31. " MAI_DSPIDL24          ,reflects the state of the marvell msa core (not marvell msa subsystem). the availability of the marvell msa subsystem memories and peripheral bus to the marvell seagull/mohawk core is still governed by means of mpcrx[dspsd], and is not reflected by this bit.  0 = marvell msa core is currently not in idle state  1 = marvell msa core is currently in idle state" "0,1"
        bitfld.long 0x00 30. "       AP_IDLE25             ,reflects the state of the marvell mohawk core.  0x1= core is in external idle or power off mode" "0,1"
        bitfld.long 0x00 29. "     MAI_SG_IDLE26                ,1 = <var processor: comm> is idle   0 = <var processor: comm> is active" "0,1"
        bitfld.long 0x00 28. "       MAI_DSPAVL27             ,marvell msa subsystem availability indication. this field should be read after mpcrx[dspsd] is deasserted, to verify the clock is resumed  0 = marvell msa subsystem clock is not running  1 = marvell msa subsystem clock is running" "0,1"
        textline "                          "
        bitfld.long 0x00 27. "AP_WFI28              ,reflects the state of the marvell mohawk core.  0 = marvell mohawk core is currently not in wfi state  1 = marvell mohawk core is currently in wfi state" "0,1"
        bitfld.long 0x00 26. "       SG_WFI29              , seagull wfi flag. it reflects the wfi flag that is directly output from seagull. when seagull enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 25. "     APOFF30                      ,reflects the power state of the marvell mohawk core.   1 = core is currently in power-off mode" "0,1"
        bitfld.long 0x00 24. "       MAI_COMM_TOP_D231        ,reflects the power state of comm_top   1 = comm_top is in d2 mode. in this mode, msa/seagull are powered off" "0,1"
        textline "                          "
        bitfld.long 0x00 0.--3. "MAI_COMM_TOP_STATE33  ,comm_top low power state   0x8=comm_top is in d0 state    0xb=comm_top is in d2 state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4050008++0x03
    line.long 0x00 "FCCR,Frequency Change Control Register"
        bitfld.long 0x00 28. " I2SCLKSEL             ,i<super 2>s divider clock selection  1 = from vctcxo  0 = from 312 mhz clock" "0,1"
        hexmask.long.word 0x00 0.--8. 1. "       PLL1FBD44             ,actually this register bits are not used in auiqla, it's fixed to 0x30 now."

group d:0xD405000C++0x03
    line.long 0x00 "POCR,PLL and Oscillator Control Register"
        bitfld.long 0x00 31. " FORCE                 ,force all  clocks to be free running  0 = this field does not affect  clock gating  1 = all  output clocks are never gated" "0,1"
        hexmask.long.byte 0x00 16.--23. 1. "       VCXOST                ,determines the wait time for vctcxo and clock limiter stabilization. referred to as d1 in table 36.  0x0 = wait time = one 32.768 khz clock cycle  0x1 = wait time = two 32.768 khz clock cycles  \xc9   0xe5  wait time = 230 32.768 khz clock cycles  0xe6  reserved  \xc9   0xff  reserved"
        hexmask.long.word 0x00 0.--11. 1. "    WAITPLLLOCKTIMEVALUE         ,determines the wait time for pll lock. referred to as d2 in table 36. this value determines lock time for both plls (pll1 and pll2).  0x0 = main pll lock time = 1 vctcxo/2 cycle   0x1 = main pll lock time = 2 vctcxo/2 cycles           \xc9   0xfff  main pll lock time = 4096 vctcxo/2 cycles"

group d:0xD4050010++0x03
    line.long 0x00 "POSR,PLL and Oscillator Status Register"
        bitfld.long 0x00 27. " MAI_PLL1_LOCK63       ,1: pll1 is locked" "0,1"
        hexmask.long.byte 0x00 18.--25. 1. "       PLL2REFD              ,pll2 refdiv  decoding -tbd"
        hexmask.long.word 0x00 9.--17. 1. "    PLL2FBD                      ,pll2 fbdiv   decoding - tbd"
        hexmask.long.word 0x00 0.--8. 1. "    PLL1FBD67                ,pll1 fbdiv   decoding - tbd"

group d:0xD4050014++0x03
    line.long 0x00 "SUCCR,Slow UART (UART 1) Clock Generation Control Register"
        hexmask.long.word 0x00 16.--28. 1. " UARTDIVN              ,uart clock generation programmable divider numerator value.  the uart clock is generated using a fractional divider. see section 1.5.2.3, slow uart clock divider programming, on page 73 for calculating the required values. this divider configuration is common to all uart modules"
        hexmask.long.word 0x00 0.--12. 1. "    UARTDIVD              ,uart clock generation programmable divider denominator value.  the uart clock is generated using a fractional divider. see section 1.5.2.3, slow uart clock divider programming, on page 73 for calculating the required values. this divider configuration is common to all uart modules"

group d:0xD4050018++0x03
    line.long 0x00 "VRCR,VCTCXO SW request Control Register"
        hexmask.long.tbyte 0x00 9.--31. 1. " MAI_83                ,"
        bitfld.long 0x00 8. "  SW_REQ                ,sw request of vctcxo" "0,1"
        bitfld.long 0x00 7. "     MAI_85                       ," "0,1"
        bitfld.long 0x00 6. "       REQ_POL2                 ,vcxo_req2 request polarity" "0,1"
        textline "                          "
        bitfld.long 0x00 5. "REQ_POL1              ,vcxo_req1 request polarity" "0,1"
        bitfld.long 0x00 4. "       REQ_POL0              ,vcxo_req request polarity" "0,1"
        bitfld.long 0x00 3. "     MAI_89                       ," "0,1"
        bitfld.long 0x00 2. "       REQ_EN2                  ,enable vcxo_req2 for vcxo_out2" "0,1"
        textline "                          "
        bitfld.long 0x00 1. "REQ_EN1               ,enable vcxo_req1 for vcxo_out1" "0,1"
        bitfld.long 0x00 0. "       REQ_EN0               ,enable vcxo_req for vcxo_out" "0,1"

group d:0xD405001C++0x03
    line.long 0x00 "PLL3CR,PLL3 Control Register"
        bitfld.long 0x00 30.--31. " PLL3SSC_MODE          ,spectrum spread mode 00: center-spread 01: up-spread 10: down-spread 11: down-spread" "0,1,2,3"
        bitfld.long 0x00 29. "       MAI_SSC_FORCE_LOCK100 ,set pll force lock  0: disable 1: enable, when reg3<4>=0, set force lock to pll_lk signal" "0,1"
        bitfld.long 0x00 28. "     MAI_SPRD_DEP_STEP101         ,increase spectrum spread depth by 2 0: disable 1: spread depth x2" "0,1"
        bitfld.long 0x00 24.--27. "       MAI_SPRD_DEP102          ,set spectrum spread depth(peak-peak) 0000: no ssc 0001: 500ppm 0010: 1000ppm 0011: 1500ppm 0100: 2000ppm 0101: 2500ppm 0110: 3000ppm 0111: 3500ppm 1000: 4000ppm 1001: 4500ppm 1010: 5000ppm 1011: 5500ppm 1100: 6000ppm 1101: 6000ppm 1110: 6000ppm 1111: 6000ppm" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                          "
        bitfld.long 0x00 19. "PLL3_PU               ,pll3 power on  0 = pll off  1 = pll on; pll3 is automatically off whenever pll is off." "0,1"
        hexmask.long.byte 0x00 8.--14. 1. "       PLL3_FBDIV            ,pll3 fbdiv"
        hexmask.long.byte 0x00 0.--7. 1. "    PLL3_FRCDIV                  ,pll3 frcdiv"

group d:0xD4050028++0x03
    line.long 0x00 "CRSR,Marvell Seagull/Mohawk Reset Status Register"
        bitfld.long 0x00 8.--11. " MAI_SWR116            ,software controlled, reset events tracking field. this field may be written (and read) to any value between 0x0 and 0xf.   this field's content does not affect  functionality in any way" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 2. "      MAI_WDTR118           ,indicates whether the last system reset was caused by a watchdog timer reset event  0 = last system reset was not caused by watchdog timer reset  1 = last system reset was caused by watchdog timer reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"
        bitfld.long 0x00 1. "     MAI_EMR119                   ,indicates whether the last system reset was caused by an external master reset event  0 = last system reset was not caused by external master reset  1 = last system reset was caused by external master reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"
        bitfld.long 0x00 0. "       MAI_POR120               ,indicates whether the last system reset was caused by a power on reset  event  0 = last system reset was not caused by power on reset  1 = last system reset was caused by power on reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"

group d:0xD405002C++0x03
    line.long 0x00 "XDCR,Delay control register for WFSTATE"
        hexmask.long.byte 0x00 24.--31. 1. " XDCR_TIE4             ,pmost_cnt_done (pmose to drowsy)"
        hexmask.long.byte 0x00 16.--23. 1. "      XDCR_TO2              ,firewall_cnt2-done (from firewall to prefirewall2)"
        hexmask.long.word 0x00 0.--15. 1. "    XDCR_TO1                     ,nmos_cnt2_done (from nmos2 to firewall)"

group d:0xD4050030++0x03
    line.long 0x00 "GPCR,General Purpose Clock Generation Control Register"
        hexmask.long.word 0x00 16.--31. 1. " GPCDIVN               ,general purpose clock generation programmable divider numerator value.  this clock is generated using a fractional divider, off the vctcxo clock. see section 1.5.2.3, slow uart clock divider programming, on page 73 for examples of calculating the programmed values."
        hexmask.long.word 0x00 0.--15. 1. "    GPCDIVD               ,general purpose clock generation programmable divider denominator value.  this clock is generated using a fractional divider, off the vctcxo clock. see section 1.5.2.3, slow uart clock divider programming, on page 73 for examples of calculating the programmed values."

group d:0xD4050034++0x03
    line.long 0x00 "PLL2CR,PLL2 Control Register"
        bitfld.long 0x00 30.--31. " PLL2SSC_MODE          ,spectrum spread mode 00: center-spread 01: up-spread 10: down-spread 11: down-spread" "0,1,2,3"
        bitfld.long 0x00 29. "       MAI_SSC_FORCE_LOCK145 ,set pll force lock  0: disable 1: enable, when reg3<4>=0, set force lock to pll_lk signal" "0,1"
        bitfld.long 0x00 28. "     MAI_SPRD_DEP_STEP146         ,increase spectrum spread depth by 2 0: disable 1: spread depth x2" "0,1"
        bitfld.long 0x00 24.--27. "       MAI_SPRD_DEP147          ,set spectrum spread depth(peak-peak) 0000: no ssc 0001: 500ppm 0010: 1000ppm 0011: 1500ppm 0100: 2000ppm 0101: 2500ppm 0110: 3000ppm 0111: 3500ppm 1000: 4000ppm 1001: 4500ppm 1010: 5000ppm 1011: 5500ppm 1100: 6000ppm 1101: 6000ppm 1110: 6000ppm 1111: 6000ppm" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                          "
        bitfld.long 0x00 19. "PLL2_PU               ,pll2 power on  0 = pll2 off  1 = pll2 on; pll3 is automatically off whenever pll1 is off." "0,1"
        hexmask.long.byte 0x00 8.--14. 1. "       PLL2_FBDIV            ,pll2 fbdiv"
        hexmask.long.byte 0x00 0.--7. 1. "    PLL2_FRCDIV                  ,pll2 frcdiv"

group d:0xD4050038++0x03
    line.long 0x00 "SCCR,Slow Clock Control Register"
        bitfld.long 0x00 2. " BB_F_SLP_EN           ,force modem into sleep mode." "0,1"
        bitfld.long 0x00 1. "       AFE_CLK_EN            ,afe calibration clock (26 mhz vcxo) enable  0 = disable  1 = enable" "0,1"
        bitfld.long 0x00 0. "     SCS                          ,slow clock select:  0 = 32khz internal clock is derived from vctcxo divider  1 = 32khz internal clock uses 32khz clock input" "0,1"

group d:0xD4050040++0x03
    line.long 0x00 "ISCCRx,I2S Clock Generation Control Register"
        bitfld.long 0x00 31. " MAI_SYSCLK_EN169      ,enables the i2s clock input to sysclkn generator as well as the output of the generator." "0,1"
        bitfld.long 0x00 30. "       MAI_SYSCLK_BASE170    ,selects the i2s m/n divider input clock frequency:  0 = sysclkn generator base clock rate is 26 mhz  1 = sysclkn generator base clock rate is 156 mhz." "0,1"
        bitfld.long 0x00 29. "     MAI_BITCLK_EN171             ,enables the i2s clock input to the bit clock generator." "0,1"
        bitfld.long 0x00 27.--28. "       MAI_BITCLK_DIV_468172    ,determine bitclk1:sysclk1 relation:  0x0 = reserved  0x1 = bitclk1 rate is the sysclk1 rate divide by 4  0x2 = bitclk1 rate is the sysclk1 rate divide by 6  0x3 = bitclk1 rate is the sysclk1 rate divide by 8" "0,1,2,3"
        textline "                          "
        hexmask.long.word 0x00 15.--26. 1. "MAI_DENOM173          ,i2s clock generation programmable divider denominator value.  the i2s sysclk is generated using a fractional divider. see section 1.5.2.4, i2s clock divider programming, on page 74 for calculating the required values."
        hexmask.long.word 0x00 0.--14. 1. "    MAI_NOM174            ,i2s clock generation programmable divider numerator value.  the i2s sysclk is generated using a fractional divider. see section 1.5.2.4, i2s clock divider programming, on page 74 for calculating the required values."

group d:0xD405004C++0x03
    line.long 0x00 "PLL5CR,PLL5 Control Register"
        bitfld.long 0x00 30.--31. " PLL5SSC_MODE181       ,spectrum spread mode 00: center-spread 01: up-spread 10: down-spread 11: down-spread" "0,1,2,3"
        bitfld.long 0x00 29. "       MAI_SSC_FORCE_LOCK182 ,set pll force lock  0: disable 1: enable, when reg3<4>=0, set force lock to pll_lk signal" "0,1"
        bitfld.long 0x00 28. "     MAI_SPRD_DEP_STEP183         ,increase spectrum spread depth by 2 0: disable 1: spread depth x2" "0,1"
        bitfld.long 0x00 24.--27. "       MAI_SPRD_DEP184          ,set spectrum spread depth(peak-peak) 0000: no ssc 0001: 500ppm 0010: 1000ppm 0011: 1500ppm 0100: 2000ppm 0101: 2500ppm 0110: 3000ppm 0111: 3500ppm 1000: 4000ppm 1001: 4500ppm 1010: 5000ppm 1011: 5500ppm 1100: 6000ppm 1101: 6000ppm 1110: 6000ppm 1111: 6000ppm" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                          "
        bitfld.long 0x00 19. "PLL5_PU               ,pll5 power on  0 = pll5 off  1 = pll on; pll5 is automatically off whenever pll is off." "0,1"
        hexmask.long.byte 0x00 8.--14. 1. "       PLL5_FBDIV            ,pll5 fbdiv"
        hexmask.long.byte 0x00 0.--7. 1. "    PLL5_FRCDIV                  ,pll5 frcdiv"

group d:0xD4050050++0x03
    line.long 0x00 "PLL4CR,PLL4 Control Register"
        bitfld.long 0x00 30.--31. " PLL5SSC_MODE196       ,spectrum spread mode 00: center-spread 01: up-spread 10: down-spread 11: down-spread" "0,1,2,3"
        bitfld.long 0x00 29. "       MAI_SSC_FORCE_LOCK197 ,set pll force lock  0: disable 1: enable, when reg3<4>=0, set force lock to pll_lk signal" "0,1"
        bitfld.long 0x00 28. "     MAI_SPRD_DEP_STEP198         ,increase spectrum spread depth by 2 0: disable 1: spread depth x2" "0,1"
        bitfld.long 0x00 24.--27. "       MAI_SPRD_DEP199          ,set spectrum spread depth(peak-peak) 0000: no ssc 0001: 500ppm 0010: 1000ppm 0011: 1500ppm 0100: 2000ppm 0101: 2500ppm 0110: 3000ppm 0111: 3500ppm 1000: 4000ppm 1001: 4500ppm 1010: 5000ppm 1011: 5500ppm 1100: 6000ppm 1101: 6000ppm 1110: 6000ppm 1111: 6000ppm" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                          "
        bitfld.long 0x00 19. "PLL4_PU               ,pll4 power on  0 = pll off  1 = pll on; pll4 is automatically off whenever pll4 is off." "0,1"
        hexmask.long.byte 0x00 8.--14. 1. "       PLL4_FBDIV            ,pll4 fbdiv"
        hexmask.long.byte 0x00 0.--7. 1. "    PLL4_FRCDIV                  ,pll4 frcdiv"

group d:0xD4050054++0x03
    line.long 0x00 "FCAP,<var Processor: Application> Core Frequency Change Control Register"
        bitfld.long 0x00 8.--10. " C2_PLLSEL             ,<var processor: application> cluster2 core clock selection  0x0 = pll1 1248 mhz  0x1 = pll1 832 mhz     0x2= pll3_div2(1.05g)   0x3=pll2_div2          0x4=pll5_div1   0x5=pll6_div1      0x6=pll4_div1(1.75g)             0x7=pll3_div1(2.1g)" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 4.--6. "       C1_PLLSEL             ,<var processor: application> cluster1 core clock selection  0x0 = pll1 1248 mhz  0x1 = pll1 832 mhz     0x2= pll3_div2(1.05g)   0x3=pll2_div2   0x4=pll5_div1   0x5=pll6_div1   0x6=pll4_div1(1.75g)    0x7 = reserved" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0.--2. "     C0_PLLSEL                    ,<var processor: application> cluster0 core clock selection  0x0 = pll1 624 mhz  0x1 = pll1 832 mhz     0x2= pll1 499mhz    0x3 = pll3_div2(1.05g)    0x4 = pll1 1248mhz     0x5~0x7 reserved" "0,1,2,3,4,5,6,7"

group d:0xD405005C++0x03
    line.long 0x00 "FCDCLK,DCLK Frequency Change Control Register"
        bitfld.long 0x00 0.--2. " MAI_DCLKSEL225        ,ddr clock selection                7=pll3 div2                               6=pll5 div2                              0x5 = pll4 div2                             0x4 = pll2 div2                          0x3 = pll6_div1                           0x2 = pll2 div1                     0x1= pll1 832 mhz                          0x0 = pll1 624 mhz" "0,1,2,3,4,5,6,7"

group d:0xD4050060++0x03
    line.long 0x00 "FCACLK,ACLK Frequency Change Control Register"
        bitfld.long 0x00 0. " ACLKSEL               ,axi clock selection  0x0 = pll1 416 mhz  0x1 = pll1 312 mhz" "0,1"

group d:0xD4050100++0x03
    line.long 0x00 "DSOC,Debug Signals Output Control Register"
        bitfld.long 0x00 8. " TPCTL                 ,test points control mux select. this field determines whether the test points mux is controlled by tunit, by means of pm_ext_tpsel input port or by means of tpsel field of this register  0 = test points mux control is by means of pm_ext_tpsel input bus  1 = test points mux control is by means of dsoc[tpsel] field" "0,1"
        hexmask.long.byte 0x00 0.--6. 1. "       TPSEL                 ,test points mux select - each combination of these bits will yield a different set of signals driven on the cw_bus_out output bus. detailed description of these signals may be found in the  mas"

group d:0xD4050200++0x03
    line.long 0x00 "WDTPCR,WDT (CP Timers) Control Register"
        bitfld.long 0x00 4.--6. " MAI_FNCLKSEL253       ,0x0 = 13 mhz clock" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "       MAI_RST255            ,timers h/w reset generation (resets both apb & functional domains)  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "     MAI_FNCLK256                 ,timers + wdtfunctional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "       ABCLK                    ,cp timers and wdt apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4050210++0x03
    line.long 0x00 "RIPCCR,RIPC Control Register"
        bitfld.long 0x00 2. " MAI_RST265            ,r-ipc h/w reset generation  )  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 0. "       MAI_APBCLK267         ,r-ipc apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4050214++0x03
    line.long 0x00 "DBG,DBG Register"
        bitfld.long 0x00 1. " DBG_CP_AXI_ACCESS_MSK ,debug used. mask communicon processor axi request.  0= not mask.  1= mask." "0,1"
        bitfld.long 0x00 0. "       DBG_CP_DDR_ACCESS_MSK ,debug used. mask communicon processor ddr request.  0= not mask.  1= mask." "0,1"

group d:0xD4051000++0x03
    line.long 0x00 "APSLPW,Marvell Seagull/Mohawk Power Control Register"
        bitfld.long 0x00 24. " MAI_INTCLR285         ,interrupt clear register.   a write of 1 followed by a write of 0 to this field clears the pm_moh_wakeup_int output of .  the read value is the last value written to this field." "0,1"
        bitfld.long 0x00 23. "       MAI_SLPWP0286         ,sleep mode wake-up decoder port 0 disable  0 = wake-up port 0 is enabled  1 = wake-up port 0 is disabled" "0,1"
        bitfld.long 0x00 22. "     MAI_SLPWP1287                ,sleep mode wake-up decoder port 1 disable  0 = wake-up port 1 is enabled  1 = wake-up port 1 is disabled" "0,1"
        bitfld.long 0x00 21. "       MAI_SLPWP2288            ,sleep mode wake-up decoder port 2 disable  0 = wake-up port 2 is enabled  1 = wake-up port 2 is disabled" "0,1"
        textline "                          "
        bitfld.long 0x00 20. "MAI_SLPWP3289         ,sleep mode wake-up decoder port 3 disable  0 = wake-up port 3 is enabled  1 = wake-up port 3 is disabled" "0,1"
        bitfld.long 0x00 18. "       MAI_SLPWP4291         ,sleep mode wake-up decoder port 4 disable  0 = wake-up port 4 is enabled  1 = wake-up port 4 is disabled" "0,1"
        bitfld.long 0x00 17. "     MAI_SLPWP5292                ,sleep mode wake-up decoder port 5 disable  0 = wake-up port 5 is enabled  1 = wake-up port 5 is disabled" "0,1"
        bitfld.long 0x00 16. "       MAI_SLPWP6293            ,sleep mode wake-up decoder port 6 disable  0 = wake-up port 6 is enabled  1 = wake-up port 6 is disabled" "0,1"
        textline "                          "
        bitfld.long 0x00 15. "MAI_SLPWP7294         ,sleep mode wake-up decoder port 7 disable  0 = wake-up port 7 is enabled  1 = wake-up port 7 is disabled" "0,1"

group d:0xD4051004++0x03
    line.long 0x00 "APSR,Marvell Seagull/Mohawk Power Status Register"
        bitfld.long 0x00 31. " MAI_DSPIDL303         ,reflects the state of the marvell msa core (not marvell msa subsystem). the availability of the marvell msa subsystem memories and peripheral bus to the marvell seagull/mohawk core is still governed by means of mpcrx[dspsd], and is not reflected by this bit.  0 = marvell msa core is currently not in idle state  1 = marvell msa core is currently in idle state" "0,1"
        bitfld.long 0x00 30. "       AP_IDLE304            ,reflects the state of the marvell mohawk core.  0x1= core is in external idle or power off mode" "0,1"
        bitfld.long 0x00 29. "     MAI_SG_IDLE305               ,1 = <var processor: comm> is idle   0 = <var processor: comm> is active" "0,1"
        bitfld.long 0x00 28. "       MAI_DSPAVL306            ,marvell msa subsystem availability indication. this field should be read after mpcrx[dspsd] is deasserted, to verify the clock is resumed  0 = marvell msa subsystem clock is not running  1 = marvell msa subsystem clock is running" "0,1"
        textline "                          "
        bitfld.long 0x00 27. "AP_WFI307             ,reflects the state of the marvell mohawk core.  0 = marvell mohawk core is currently not in wfi state  1 = marvell mohawk core is currently in wfi state" "0,1"
        bitfld.long 0x00 26. "       SG_WFI308             , seagull wfi flag. it reflects the wfi flag that is directly output from seagull. when seagull enters wfi, this field will be set." "0,1"
        bitfld.long 0x00 25. "     APOFF309                     ,reflects the power state of the marvell mohawk core.   1 = core is currently in power-off mode" "0,1"
        bitfld.long 0x00 24. "       MAI_COMM_TOP_D2310       ,reflects the power state of comm_top   1 = comm_top is in d2 mode. in this mode, msa/seagull are powered off" "0,1"
        textline "                          "
        bitfld.long 0x00 0.--3. "MAI_COMM_TOP_STATE312 ,comm_top low power state   0x8=comm_top is in d0 state    0xb=comm_top is in d2 state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD4051020++0x03
    line.long 0x00 "APRR,Marvell Seagull/Mohawk Programmable Reset Register"
        bitfld.long 0x00 31. " SGR_SEL               ,communication processor reset mode select.  1=direct mode. set cpr will reset communication processor immediately.  0=silent reset mode. set cpr will not reset communication processor immediately. only when all communication processor memory and register request finished, communication processor can be reseted." "0,1"
        bitfld.long 0x00 30. "       SGR_RST               ,communication processor reset status.  1= communication processor at reset state.  0=communication at active state." "0,1"
        hexmask.long.tbyte 0x00 9.--29. 1. "     SIRST_CNT                    ,communication processor silent reset wait time this field determines the wait time for the completion of a silent reset to communication processor. when the wait counter has reached this value, silrst is set to 1."
        bitfld.long 0x00 8. "  RST_DONE                 ,reset done flag. this bit is set when sirst_cnt counter to 0" "0,1"
        textline "                          "
        bitfld.long 0x00 6. "MAI_SLAVE_R324        ,slave_reset_out pin sw reset control  1 = slave_reset_out is low.  0 = slave_reset_out may be high base on reset_in and wdt reset." "0,1"
        bitfld.long 0x00 5. "       MAI_DSRAMINT325       ,this signal hold the msa from start execution after released from reset. it will be used to hold msa from start execution till his boot address in sram will be initial with valid code.  1 = execution is hold  0 = msa is running" "0,1"
        bitfld.long 0x00 4. "     MAI_WDTR326                  ,negate hardware reset to the wdt after system reset. this field is reset due to a wdt reset event  reading 0 = wdt reset is still asserted from the last system reset  reading 1 = wdt reset is negated  writing 0 = operation is ignored  writing 1 = negates the wdt reset  the actual release of the wdt reset signal might be delayed by up to 11/2 cycles of the 32.768 khz clock" "0,1"
        bitfld.long 0x00 3. "       MAI_BBR327               ,apply global hardware reset to the baseband logic  0 = hardware reset is negated  1 = hardware reset is asserted  the baseband logic reset is effected also from dprr register." "0,1"
        textline "                          "
        bitfld.long 0x00 2. "MAI_DSPR328           ,apply global hardware reset to the whole marvell msa subsystem.  0 = hardware reset is negated  1 = hardware reset is asserted" "0,1"
        bitfld.long 0x00 1. "       MAI_APR329            ,this is read only bit - cp_wf_fuse  0 = mohawk core was the second core to boot  1 = mohawk core was the first core to boot." "0,1"
        bitfld.long 0x00 0. "     MAI_CPR330                   ,apply hardware reset to the communication processor (seagull core).  1 = core is hold in reset.  0 = core is released from reset  the initial value of this bit is determined by cp_wf_fuse_not  cp_wf_fuse = 1 (seagull core is the first one to boot).  cp_wf_fose not is 0 when seagull wakeup first" "0,1"

group d:0xD4051024++0x03
    line.long 0x00 "ACGR,Marvell Seagull/Mohawk Clock Gating Register"
        bitfld.long 0x00 19. " MAI_WDT_13M339        ,enable the functional 13 mhz clock output of the main  to the watchdogtimer.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 16. "       MAI_CLK_1248M341      ,enable the functional 1248 mhz clock output.   0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 15. "     MAI_CLK_624M342              ,enable the functional 624 mhz clock output.   0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 14. "       MAI_CLK_832M343          ,enable the functional 832 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        textline "                          "
        bitfld.long 0x00 13. "MAI_CLK_312M344       ,enable the functional 312 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 12. "       MAI_CLK_104M345       ,enable the functional 104 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 11. "     MAI_CLK_52M346               ,enable the functional 52 mhz clock output for ap pmu and ap perihrals.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 10. "       MAI_CLK_48M347           ,enable the functional 48 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        textline "                          "
        bitfld.long 0x00 9. "MAI_GPC348            ,enable the m/n clock generator of the vcxo clockconfigured through gpcr, the clcok is output to vcxo_out pad func3  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 8. "       MAI_AP_FUART349       ,enable the functional fast uart clock output (58.5 mhz) of the main  to the application processor apb portion.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 7. "     MAI_CLK_52M350               ,enable the functional 52 mhz clock output for apb peripherals  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 6. "       MAI_AP_TWSI351           ,enable the 32m clock of the functional twsi clock output of the main  to the application processor apb portion.  0 = clock not enabled  1 = clock enabled" "0,1"
        textline "                          "
        bitfld.long 0x00 5. "MAI_CLK_208M352       ,enable the functional 208 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 4. "       MAI_CLK_26M353        ,enable the functional 26 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 3. "     MAI_CLK_13M354               ,enable the functional 13 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 2. "       MAI_CLK_6.5M355          ,enable the functional 6.5 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        textline "                          "
        bitfld.long 0x00 1. "MAI_AP_SUART356       ,enable the functional m/n slow uart clock output (configured through succr) of the main  to the application processor apb portion. it's just uart slow clock(14.17m) source enable   0 = clock not enabled  1 = clock enabled." "0,1"
        bitfld.long 0x00 0. "       MAI_CLK_416M357       ,enable the functional 416 mhz clock output.   0 = clock not enabled  1 = clock enabled" "0,1"

group d:0xD4051028++0x03
    line.long 0x00 "ARSR,Marvell Seagull/Mohawk Reset Status Register"
        bitfld.long 0x00 8.--11. " MAI_SWR366            ,software controlled, reset events tracking field. this field may be written (and read) to any value between 0x0 and 0xf.   this field's content does not affect  functionality in any way" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 2. "      MAI_WDTR368           ,indicates whether the last system reset was caused by a watchdog timer reset event  0 = last system reset was not caused by watchdog timer reset  1 = last system reset was caused by watchdog timer reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"
        bitfld.long 0x00 1. "     MAI_EMR369                   ,indicates whether the last system reset was caused by an external master reset event  0 = last system reset was not caused by external master reset  1 = last system reset was caused by external master reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"
        bitfld.long 0x00 0. "       MAI_POR370               ,indicates whether the last system reset was caused by a power on reset  event  0 = last system reset was not caused by power on reset  1 = last system reset was caused by power on reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"

group d:0xD4051030++0x03
    line.long 0x00 "PWRMODE_STAUTS,Power Mode Status Register"
        hexmask.long.word 0x00 16.--31. 1. " PWRMODE_STATUS377     ,this field indicates that the system has entered and exited which state. one bit for one low power mode. if set to 1 indicate the low power mode has occured. it is cleared by set 1 to approprate bit of clr_pwrmode_status  bit0 for d1p mode  bit1 for d1pp mode   bit2 for d1 mode  bit3 for d2 mode  bit 4 for d2p   bit5 for d2pp mode  bit6 for cluster0 m2  bit7 for cluster1 m2"
        hexmask.long.word 0x00 16.--31. 1. "    PWRMODE_STATUS378     ,this field indicates that the system has entered and exited which state. one bit for one low power mode. if set to 1 indicate the low power mode has occured. it is cleared by set 1 to approprate bit of clr_pwrmode_status  bit0 for d1p mode  bit1 for d1pp mode   bit2 for d1 mode  bit3 for d2 mode  bit 4 for d2p   bit5 for d2pp mode  bit6 for cluster0 m2  bit7 for cluster1 m2  bit8 for cluster2 m2"
        hexmask.long.word 0x00 0.--15. 1. "  CLR_PWRMODE_STATUS           ,clear power mode status. set 1 to cleare approprate of pwrmode_status bit."

group d:0xD4051048++0x03
    line.long 0x00 "AWUCRS,Wakeup and Clock Resume Lines Status Register"
        bitfld.long 0x00 31. " MAI_BB_DROWSY_EN386   ,bb_drowsy_en" "0,1"
        bitfld.long 0x00 30. "       MAI_BB_VCTCXO_REQ387  ,bb_vctcxo_req" "0,1"
        bitfld.long 0x00 29. "     MAI_MSA_WAKE_PM_BB_CLKRES388 ,msa_wake/pm_bb_clkres" "0,1"
        bitfld.long 0x00 28. "       MAI_PM_CLKRES389         ,pm_clkres" "0,1"
        textline "                          "
        bitfld.long 0x00 27. "MAI_GSM_WAKEUP390     ,gsm wakeup" "0,1"
        bitfld.long 0x00 26. "       MAI_FB_WAKEUP391      ,fb wakeup" "0,1"
        bitfld.long 0x00 25. "     MAI_AP_ASYNC_INT392          ,ap async int" "0,1"
        bitfld.long 0x00 24. "       MAI_AP_FULL_IDLE393      ,ap full idle" "0,1"
        textline "                          "
        bitfld.long 0x00 23. "MAI_SDH1_AUDIO394     ,sdh1/audio wakeup" "0,1"
        bitfld.long 0x00 22. "       MAI_SDH2395           ,sdh2 wakeup" "0,1"
        bitfld.long 0x00 21. "     MAI_KEYPRESS396              ,keypress" "0,1"
        bitfld.long 0x00 20. "       MAI_TRACKBALL397         ,trackball" "0,1"
        textline "                          "
        bitfld.long 0x00 19. "MAI_NEWROTARY398      ,newrotary" "0,1"
        bitfld.long 0x00 18. "       MAI_WDT399            ,wdt" "0,1"
        bitfld.long 0x00 17. "     MAI_RTC_ALARM400             ,rtc alarm" "0,1"
        bitfld.long 0x00 16. "       MAI_CP_TIMER_3401        ,cp timer 3" "0,1"
        textline "                          "
        bitfld.long 0x00 15. "MAI_CP_TIMER_2402     ,cp timer 2" "0,1"
        bitfld.long 0x00 14. "       MAI_CP_TIMER_1403     ,cp timer 1" "0,1"
        bitfld.long 0x00 13. "     MAI_AP1_TIMER_3404           ,ap1 timer 3" "0,1"
        bitfld.long 0x00 12. "       MAI_AP1_TIMER_2405       ,ap1 timer 2" "0,1"
        textline "                          "
        bitfld.long 0x00 11. "MAI_AP1_TIMER_1406    ,ap1 timer 1" "0,1"
        bitfld.long 0x00 10. "       MAI_AP0_2_TIMER_3407  ,ap0 timer 3 and ap2 timer 3" "0,1"
        bitfld.long 0x00 9. "     MAI_AP0_2_TIMER_2408         ,ap0 timer 2 and ap2 timer 2" "0,1"
        bitfld.long 0x00 8. "       MAI_AP0_2_TIMER_1409     ,ap0 timer 1 and ap2 timer 1" "0,1"
        textline "                          "
        bitfld.long 0x00 7. "MAI_WAKEUP7410        ,wakeup7 line in status" "0,1"
        bitfld.long 0x00 6. "       MAI_WAKEUP6411        ,wakeup6 line in status" "0,1"
        bitfld.long 0x00 5. "     MAI_WAKEUP5412               ,wakeup5 line in status" "0,1"
        bitfld.long 0x00 4. "       MAI_WAKEUP4413           ,wakeup4 line in status" "0,1"
        textline "                          "
        bitfld.long 0x00 3. "MAI_WAKEUP3414        ,wakeup3 line in status" "0,1"
        bitfld.long 0x00 2. "       MAI_WAKEUP2415        ,wakeup2 line in status" "0,1"
        bitfld.long 0x00 1. "     MAI_WAKEUP1416               ,wakeup1 line in status" "0,1"
        bitfld.long 0x00 0. "       MAI_WAKEUP0417           ,wakeup0 line in status" "0,1"

group d:0xD405104C++0x03
    line.long 0x00 "AWUCRM,Wakeup and Clock Resume Lines Mask Register"
        bitfld.long 0x00 31. " MAI_AUDIO_WAKEUP424   ,mask audio_wakeup" "0,1"
        bitfld.long 0x00 30. "       MAI_AP_GT_WAKEUP425   ,mask ap generic timer wakeup" "0,1"
        bitfld.long 0x00 29. "     MAI_GSM_WAKEUPWMX426         ,mask gsm wakeup from pm_clkres" "0,1"
        bitfld.long 0x00 28. "       MAI_FB_WAKEUPX427        ,mask fb wakeup from pm_clkres" "0,1"
        textline "                          "
        bitfld.long 0x00 27. "MAI_GSM_WAKEUPWM428   ,mask gsm wakeup from msa_wake" "0,1"
        bitfld.long 0x00 26. "       MAI_FB_WAKEUPWM429    ,mask fb wakeup rom msa_wake" "0,1"
        bitfld.long 0x00 25. "     MAI_AP_ASYNC_INT430          ,mask ap async int from pm_clkres" "0,1"
        bitfld.long 0x00 24. "       MAI_AP_FULL_IDLE431      ,mask ap full idle from pm_clkres" "0,1"
        textline "                          "
        bitfld.long 0x00 23. "MAI_SDH1_AUDIO432     ,mask sdh1/audio wakeup" "0,1"
        bitfld.long 0x00 22. "       MAI_SDH2433           ,mask sdh2 wakeup" "0,1"
        bitfld.long 0x00 21. "     MAI_KEYPRESS434              ,mask keypress wakeup" "0,1"
        bitfld.long 0x00 20. "       MAI_TRACKBALL435         ,mask trackball wakeup" "0,1"
        textline "                          "
        bitfld.long 0x00 19. "MAI_NEWROTARY436      ,mask newrotary wakeup" "0,1"
        bitfld.long 0x00 18. "       MAI_WDT437            ,mask wdt wakeup" "0,1"
        bitfld.long 0x00 17. "     MAI_RTC_ALARM438             ,mask rtc alarm wakeup" "0,1"
        bitfld.long 0x00 16. "       MAI_CP_TIMER_3439        ,mask cp timer int3 wakeup" "0,1"
        textline "                          "
        bitfld.long 0x00 15. "MAI_CP_TIMER_2440     ,mask cp timer int2 wakeup" "0,1"
        bitfld.long 0x00 14. "       MAI_CP_TIMER_1441     ,mask cp timer int1 wakeup" "0,1"
        bitfld.long 0x00 13. "     MAI_AP1_TIMER_3442           ,mask ap timer1 int3 wakeup" "0,1"
        bitfld.long 0x00 12. "       MAI_AP1_TIMER_2443       ,mask ap timer1 int2 wakeup" "0,1"
        textline "                          "
        bitfld.long 0x00 11. "MAI_AP1_TIMER_1444    ,mask ap timer1 int1 wakeup" "0,1"
        bitfld.long 0x00 10. "       MAI_AP0_2_TIMER_3445  ,mask ap timer0 and ap timer2 int3 wakeup" "0,1"
        bitfld.long 0x00 9. "     MAI_AP0_2_TIMER_2446         ,mask ap timer0 and ap timer2 int2 wakeup" "0,1"
        bitfld.long 0x00 8. "       MAI_AP0_2_TIMER_1447     ,mask ap timer0 and ap timer2 int1 wakeup" "0,1"
        textline "                          "
        bitfld.long 0x00 7. "MAI_WAKEUP7448        ,mask wakeup7 input to pm_clkres" "0,1"
        bitfld.long 0x00 6. "       MAI_WAKEUP6449        ,mask wakeup6 input to pm_clkres" "0,1"
        bitfld.long 0x00 5. "     MAI_WAKEUP5450               ,mask wakeup5 input to pm_clkres" "0,1"
        bitfld.long 0x00 4. "       MAI_WAKEUP4451           ,mask wakeup4 input to pm_clkres" "0,1"
        textline "                          "
        bitfld.long 0x00 3. "MAI_WAKEUP3452        ,mask wakeup3 input to pm_clkres" "0,1"
        bitfld.long 0x00 2. "       MAI_WAKEUP2453        ,mask wakeup2 input to pm_clkres" "0,1"
        bitfld.long 0x00 1. "     MAI_WAKEUP1454               ,mask wakeup1input to pm_clkres" "0,1"
        bitfld.long 0x00 0. "       MAI_WAKEUP0455           ,mask wakeup0 input to pm_clkres" "0,1"

group d:0xD4051050++0x03
    line.long 0x00 "APBCSCR,APB Clock Source Control Register"
        bitfld.long 0x00 0. " APB_52M               ,system apb clk source selection  0 = clock is 26 mhz  1 = clock is 52 mhz" "0,1"

group d:0xD4051064++0x03
    line.long 0x00 "AWUCRS1,Wakeup and Clock Resume Lines Status Register1"
        bitfld.long 0x00 0. " MAI_AP_GT_WAKEUP472   ,ap generic timer wakeup status" "0,1"

group d:0xD4051080++0x03
    line.long 0x00 "SHGPIOCTRL,Sensor hub GPIO control "
        bitfld.long 0x00 31. " BYPASS_SH_INT0        ,this bit used to select the interrupt source for sensor hub int0 0: from gpio74 interrupt 1:from pmic interrupt" "0,1"
        bitfld.long 0x00 25. "       SGADDRMAPEN481        ,this bit control the interrupt trigger type for pmic to audio island 0:high level trigger 1:low level trigger" "0,1"
        bitfld.long 0x00 24. "     EN_PMIC_INT                  ,0:disable  1:enable" "0,1"
        hexmask.long.byte 0x00 16.--23. 1. "       GPIO_OUT_SEL             ,bit[23:16] control the out put source for gpio81,80,79,78,65,66,65,62,61 0:from ap 1:from gpo of audio island"
        textline "                          "
        hexmask.long.byte 0x00 8.--15. 1. "INT_EN                ,bit[15:8] control the interrupt enable for gpio81~gpio74 . 0:disable  1:enable"
        hexmask.long.byte 0x00 0.--7. 1. "      INT_TYPE              ,bit[7:0] control the interrupt trigger type for gpio81~gpio74 . 0:high level trigger 1:low level trigger"

group d:0xD4051084++0x03
    line.long 0x00 "SGADDRMAP,Marvell Seagull  Address Map"
        bitfld.long 0x00 16. " SGADDRMAPEN493        ,seagull address map enable  1=enable  0=disable" "0,1"
        hexmask.long.word 0x00 0.--15. 1. "       SGADDRMAPTG           ,seagull address map target address. if seagull address map enable and seagull write to 0xffff003f to 0xffffffff and seagull read from 0xffff0000 to 0xffffffff, the high 16bit address will use sgaddrmaptg."

group d:0xD4051088++0x03
    line.long 0x00 "MSAADDRMAP,MSA  Address Map"
        bitfld.long 0x00 7. " MSAADDRMAPEN          ,msa address map enable  1=enable  0=disable" "0,1"
        hexmask.long.byte 0x00 0.--6. 1. "       MSAADDRMAPTG          ,msa address map target address. if msa address map enable and msa write/read address in the range from 0xd2000000 to 0xd3ffffff, msa address high 7bit will use msaaddrmaptg"

group d:0xD4051080++0x03
    line.long 0x00 "MSAMEMCTRL,MSA Memory Control"
        bitfld.long 0x00 31. " SRAM_FUSE_REPAIR_CTRL ," "0,1"
        bitfld.long 0x00 29.--30. "       MAI_GSRAM_WTC511      ,grayback gsram wtc" "0,1,2,3"
        bitfld.long 0x00 27.--28. "     MAI_GSRAM_RTC512             ,grayback gsram rtc" "0,1,2,3"
        bitfld.long 0x00 25.--26. "       MAI_GSRAM_ROM_RTC_REF513 ,grayback l2 rom rtc ref" "0,1,2,3"
        textline "                          "
        bitfld.long 0x00 22.--24. "MAI_GSRAM_ROM_RTC514  ,grayback l2 rom rtc" "0,1,2,3,4,5,6,7"
        hexmask.long.word 0x00 22.--30. 1. "       MAI_RESERVED515       ,"
        bitfld.long 0x00 21. "  PMU2GB_WAKEUP_EN             ,mask for pmu2gb_wakeup signal: 1 = not masked; 0 = masked" "0,1"
        bitfld.long 0x00 20. "       MSA_L1_PDLVMC            ,gb l1 memory pdlvmc" "0,1"
        textline "                          "
        bitfld.long 0x00 19. "MSA_L1_PDFVSSM        ,gb l1 memory pdfvssm" "0,1"
        bitfld.long 0x00 17.--18. "       MSA_L1_RTC_SACMEM     ,gb l1 memory rtc" "0,1,2,3"
        bitfld.long 0x00 15.--16. "     MSA_L1_WTC_SACMEM            ,gb l1 memory wtc" "0,1,2,3"
        bitfld.long 0x00 14. "       MSA_TRANSACTION_FIX      ,0 = gb wrap transaction fix enable; 1 = old implementation" "0,1"
        textline "                          "
        bitfld.long 0x00 13. "MSA_AIB_GB_L2_RATIO   ,aib gb l2 sram clock ratio" "0,1"
        bitfld.long 0x00 9.--12. "       MSA_AIB_GB_L2_LATENCY ,aib gb l2 sram latency" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8. "    CPSRAM_PDFVSSM               ," "0,1"
        bitfld.long 0x00 7. "       CPSRAM_PDLVMC            ," "0,1"
        textline "                          "
        bitfld.long 0x00 5.--6. "CP_SRAM_WTC           ," "0,1,2,3"
        bitfld.long 0x00 3.--4. "       CP_SRAM_RTC           ," "0,1,2,3"
        bitfld.long 0x00 2. "     CP_SRAM_FIX_PRIOR0           ," "0,1"
        bitfld.long 0x00 1. "       CP_SRAM_PIPE_MEM         ," "0,1"
        textline "                          "
        bitfld.long 0x00 0. "CP_SRAM_CLOCK_GATING  ," "0,1"

group d:0xD4051090++0x03
    line.long 0x00 "APCR_CLUSTER0,Marvell <var Processor: Application MP> Cluster 0 Power Control Register"
        bitfld.long 0x00 31. " MAI_AXISDD538         ,allow axi bus and agents to be shut down after marvell <var processor: comm>/ <var processor: application> cores enters idle state.  0 = axi shutdown not allowed  1 = axi shutdown allowed" "0,1"
        bitfld.long 0x00 30. "       MAI_DSPSD539          ,not used" "0,1"
        bitfld.long 0x00 29. "     MAI_SLPEN540                 ,allow pmu to switch the system to sleep mode once it reached system idle mode.  0 = sleep mode not allowed  1 = sleep mode allowed" "0,1"
        bitfld.long 0x00 27. "       MAI_DDRCORSD542          ,allow marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown. the clocks are halted when cpcr[ddrcorsd], apcr[ddrcorsd] & dpcr[ddrcorsd] are set and marvell <var processor: application mp> core is in idle mode   0 = marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown not allowed  1 = marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown allowed" "0,1"
        textline "                          "
        bitfld.long 0x00 26. "MAI_APBSD543          ,allow pmu to shut down apb clock to all of its recipients, overriding other per-module fields. the apb clock is actually shut down once the marvell <var processor: comm>/ <var processor: application> cores are idle and cpcr[apbsd], apcr[apbsd] & dpcr[apbsd] are set  0 = apb clock shutdown not allowed  1 = apb clock shutdown allowed" "0,1"
        bitfld.long 0x00 25. "       MAI_BBSD544           ,allow pmu to shut down all clocks provided to the baseband logic, except 32.768 khz clock. the baseband logic clocks are halted as soon as cpcr[bbsd], apcr[bbsd] & dpcr[bbsd] are set and pm_bb_clkres port is negated.  0 = bb clocks shutdown not allowed  1 = bb clocks shutdown allowed" "0,1"
        bitfld.long 0x00 19. "     MAI_VCTCXOSD546              ,allow vctcxo shutdown when system is in sleep mode. vctcxo is shutdown when cpcr[vctcxosd], apcr[vctcxosd] & dpcr[vctcxosd] are set & the system enters sleep mode  0 = vctcxo shutdown not allowed  1 = vctcxo shutdown allowed" "0,1"
        bitfld.long 0x00 14. "       MAI_MSASLPEN548          ,allow msa to switch msa subsystem to sleep mode once it reached msa sub system idle mode.the sleep mode is allowed when cpcr[msaslpen], apcr[msaslpen] & dpcr[msaslpen]  0 = msa sleep mode not allowed  1 = msa sleep mode allowed  base on the cpmu setting, msa subsystem may be powered down." "0,1"
        textline "                          "
        bitfld.long 0x00 13. "MAI_STBYEN549         ,allow apps subsystem to shutdown and go into udr-mode when ap subsystem is in sleep mode. udr is enabled when cpcr[stbyen], apcr[stbyen] are both set & ap subsystem enters ap sleep." "0,1"
        bitfld.long 0x00 3. "       LDMA_MASK551          ,ldma mask  this field is used to mask the lte dma hardware voting for ddr shutdown.  0 = lte dma hardware voting for ddr shutdown enabled  1 = lte dma hardware voting for ddr shutdown not allowed" "0,1"

group d:0xD4051094++0x03
    line.long 0x00 "APCR_CLUSTER1,Marvell <var Processor: Application MP> Cluster 1 Power Control Register"
        bitfld.long 0x00 31. " MAI_AXISDD560         ,allow axi bus and agents to be shut down after marvell <var processor: comm>/ <var processor: application> cores enters idle state.  0 = axi shutdown not allowed  1 = axi shutdown allowed" "0,1"
        bitfld.long 0x00 30. "       MAI_DSPSD561          ,not used" "0,1"
        bitfld.long 0x00 29. "     MAI_SLPEN562                 ,allow pmu to switch the system to sleep mode once it reached system idle mode.  0 = sleep mode not allowed  1 = sleep mode allowed" "0,1"
        bitfld.long 0x00 27. "       MAI_DDRCORSD564          ,allow marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown. the clocks are halted when cpcr[ddrcorsd], apcr[ddrcorsd] & dpcr[ddrcorsd] are set and marvell <var processor: application mp> core is in idle mode   0 = marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown not allowed  1 = marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown allowed" "0,1"
        textline "                          "
        bitfld.long 0x00 26. "MAI_APBSD565          ,allow pmu to shut down apb clock to all of its recipients, overriding other per-module fields. the apb clock is actually shut down once the marvell <var processor: comm>/ <var processor: application> cores are idle and cpcr[apbsd], apcr[apbsd] & dpcr[apbsd] are set  0 = apb clock shutdown not allowed  1 = apb clock shutdown allowed" "0,1"
        bitfld.long 0x00 25. "       MAI_BBSD566           ,allow pmu to shut down all clocks provided to the baseband logic, except 32.768 khz clock. the baseband logic clocks are halted as soon as cpcr[bbsd], apcr[bbsd] & dpcr[bbsd] are set and pm_bb_clkres port is negated.  0 = bb clocks shutdown not allowed  1 = bb clocks shutdown allowed" "0,1"
        bitfld.long 0x00 19. "     MAI_VCTCXOSD568              ,allow vctcxo shutdown when system is in sleep mode. vctcxo is shutdown when cpcr[vctcxosd], apcr[vctcxosd] & dpcr[vctcxosd] are set & the system enters sleep mode  0 = vctcxo shutdown not allowed  1 = vctcxo shutdown allowed" "0,1"
        bitfld.long 0x00 14. "       MAI_MSASLPEN570          ,allow msa to switch msa subsystem to sleep mode once it reached msa sub system idle mode.the sleep mode is allowed when cpcr[msaslpen], apcr[msaslpen] & dpcr[msaslpen]  0 = msa sleep mode not allowed  1 = msa sleep mode allowed  base on the cpmu setting, msa subsystem may be powered down." "0,1"
        textline "                          "
        bitfld.long 0x00 13. "MAI_STBYEN571         ,allow apps subsystem to shutdown and go into udr-mode when ap subsystem is in sleep mode. udr is enabled when cpcr[stbyen], apcr[stbyen] are both set & ap subsystem enters ap sleep." "0,1"
        bitfld.long 0x00 3. "       LDMA_MASK573          ,ldma mask  this field is used to mask the lte dma hardware voting for ddr shutdown.  0 = lte dma hardware voting for ddr shutdown enabled  1 = lte dma hardware voting for ddr shutdown not allowed" "0,1"

group d:0xD405109C++0x03
    line.long 0x00 "APCR_CLUSTER2,Marvell <var Processor: Application MP> Cluster 2 Power Control Register"
        bitfld.long 0x00 31. " MAI_AXISDD583         ,allow axi bus and agents to be shut down after marvell <var processor: comm>/ <var processor: application> cores enters idle state.  0 = axi shutdown not allowed  1 = axi shutdown allowed" "0,1"
        bitfld.long 0x00 30. "       MAI_DSPSD584          ,not used" "0,1"
        bitfld.long 0x00 29. "     MAI_SLPEN585                 ,allow pmu to switch the system to sleep mode once it reached system idle mode.  0 = sleep mode not allowed  1 = sleep mode allowed" "0,1"
        bitfld.long 0x00 27. "       MAI_DDRCORSD587          ,allow marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown. the clocks are halted when cpcr[ddrcorsd], apcr[ddrcorsd] & dpcr[ddrcorsd] are set and marvell <var processor: application mp> core is in idle mode   0 = marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown not allowed  1 = marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown allowed" "0,1"
        textline "                          "
        bitfld.long 0x00 26. "MAI_APBSD588          ,allow pmu to shut down apb clock to all of its recipients, overriding other per-module fields. the apb clock is actually shut down once the marvell <var processor: comm>/ <var processor: application> cores are idle and cpcr[apbsd], apcr[apbsd] & dpcr[apbsd] are set  0 = apb clock shutdown not allowed  1 = apb clock shutdown allowed" "0,1"
        bitfld.long 0x00 25. "       MAI_BBSD589           ,allow pmu to shut down all clocks provided to the baseband logic, except 32.768 khz clock. the baseband logic clocks are halted as soon as cpcr[bbsd], apcr[bbsd] & dpcr[bbsd] are set and pm_bb_clkres port is negated.  0 = bb clocks shutdown not allowed  1 = bb clocks shutdown allowed" "0,1"
        bitfld.long 0x00 19. "     MAI_VCTCXOSD591              ,allow vctcxo shutdown when system is in sleep mode. vctcxo is shutdown when cpcr[vctcxosd], apcr[vctcxosd] & dpcr[vctcxosd] are set & the system enters sleep mode  0 = vctcxo shutdown not allowed  1 = vctcxo shutdown allowed" "0,1"
        bitfld.long 0x00 14. "       MAI_MSASLPEN593          ,allow msa to switch msa subsystem to sleep mode once it reached msa sub system idle mode.the sleep mode is allowed when cpcr[msaslpen], apcr[msaslpen] & dpcr[msaslpen]  0 = msa sleep mode not allowed  1 = msa sleep mode allowed  base on the cpmu setting, msa subsystem may be powered down." "0,1"
        textline "                          "
        bitfld.long 0x00 13. "MAI_STBYEN594         ,allow apps subsystem to shutdown and go into udr-mode when ap subsystem is in sleep mode. udr is enabled when cpcr[stbyen], apcr[stbyen] are both set & ap subsystem enters ap sleep." "0,1"
        bitfld.long 0x00 3. "       LDMA_MASK596          ,ldma mask  this field is used to mask the lte dma hardware voting for ddr shutdown.  0 = lte dma hardware voting for ddr shutdown enabled  1 = lte dma hardware voting for ddr shutdown not allowed" "0,1"

group d:0xD4051098++0x03
    line.long 0x00 "APCR_PER,Marvell Peripheral 1 Power Control Register"
        bitfld.long 0x00 31. " MAI_AXISDD606         ,allow axi bus and agents to be shut down after marvell <var processor: comm>/ <var processor: application> cores enters idle state.  0 = axi shutdown not allowed  1 = axi shutdown allowed" "0,1"
        bitfld.long 0x00 30. "       MAI_DSPSD607          ,not used" "0,1"
        bitfld.long 0x00 29. "     MAI_SLPEN608                 ,allow pmu to switch the system to sleep mode once it reached system idle mode.  0 = sleep mode not allowed  1 = sleep mode allowed" "0,1"
        bitfld.long 0x00 27. "       MAI_DDRCORSD610          ,allow marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown. the clocks are halted when cpcr[ddrcorsd], apcr[ddrcorsd] & dpcr[ddrcorsd] are set and marvell <var processor: application mp> core is in idle mode   0 = marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown not allowed  1 = marvell <var processor: comm>/<var processor: application mp> core and tc ddr clocks shutdown allowed" "0,1"
        textline "                          "
        bitfld.long 0x00 26. "MAI_APBSD611          ,allow pmu to shut down apb clock to all of its recipients, overriding other per-module fields. the apb clock is actually shut down once the marvell <var processor: comm>/ <var processor: application> cores are idle and cpcr[apbsd], apcr[apbsd] & dpcr[apbsd] are set  0 = apb clock shutdown not allowed  1 = apb clock shutdown allowed" "0,1"
        bitfld.long 0x00 25. "       MAI_BBSD612           ,allow pmu to shut down all clocks provided to the baseband logic, except 32.768 khz clock. the baseband logic clocks are halted as soon as cpcr[bbsd], apcr[bbsd] & dpcr[bbsd] are set and pm_bb_clkres port is negated.  0 = bb clocks shutdown not allowed  1 = bb clocks shutdown allowed" "0,1"
        bitfld.long 0x00 19. "     MAI_VCTCXOSD614              ,allow vctcxo shutdown when system is in sleep mode. vctcxo is shutdown when cpcr[vctcxosd], apcr[vctcxosd] & dpcr[vctcxosd] are set & the system enters sleep mode  0 = vctcxo shutdown not allowed  1 = vctcxo shutdown allowed" "0,1"
        bitfld.long 0x00 14. "       MAI_MSASLPEN616          ,allow msa to switch msa subsystem to sleep mode once it reached msa sub system idle mode.the sleep mode is allowed when cpcr[msaslpen], apcr[msaslpen] & dpcr[msaslpen]  0 = msa sleep mode not allowed  1 = msa sleep mode allowed  base on the cpmu setting, msa subsystem may be powered down." "0,1"
        textline "                          "
        bitfld.long 0x00 13. "MAI_STBYEN617         ,allow apps subsystem to shutdown and go into udr-mode when ap subsystem is in sleep mode. udr is enabled when cpcr[stbyen], apcr[stbyen] are both set & ap subsystem enters ap sleep." "0,1"
        bitfld.long 0x00 3. "       LDMA_MASK619          ,ldma mask  this field is used to mask the lte dma hardware voting for ddr shutdown.  0 = lte dma hardware voting for ddr shutdown enabled  1 = lte dma hardware voting for ddr shutdown not allowed" "0,1"

group d:0xD4053000++0x03
    line.long 0x00 "SPRR,Marvell Secure Core Programmable Reset Register"
        bitfld.long 0x00 7. " WDTRST                ,system hot reset  when this field is set to 1, it equals a watchdog reset event and watchdog reset generated. this field can only be write with a value of 1. writes of 0 are ignored." "0,1"
        bitfld.long 0x00 4. "       MAI_WDTR631           ,negate hardware reset to wdt after system reset  this field is reset due to a wdt reset event  reading 0 = wdt reset is still asserted from the last system reset  reading 1 = wdt reset is negated  writing 0 = operation is ignored  writing 1 = negates the wdt reset" "0,1"
        bitfld.long 0x00 1. "     SPR                          ,this is read only bit - sp_wf_fuse  0 = secure core was not boot core  1 = secure core was the first core to boot" "0,1"
        bitfld.long 0x00 0. "       MAI_APR635               ,apply hardware reset to application processor  1 = core is held in reset.  0 = core is released from reset  the initial value of this bit is determined by sp_wf_fuse_not.  sp_wf_fuse = 1 (secure core is not first one to boot).  sp_wf_fuse is 0 when secure core is boot core." "0,1"

group d:0xD4051084++0x03
    line.long 0x00 "CRMR,CR7 DDR address remap"
        bitfld.long 0x00 24. " LRME                  ,lte ddr remap enable   0 = lte ddr remap disabled 1 = lte ddr remap enabled" "0,1"
        bitfld.long 0x00 16.--20. "       LRMADDR               ,lte ddr remap address.    when lte ddr remap is enabled, lte ddr address [32:28] is replaced with lrmaddr[4:0] in this field" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"
        bitfld.long 0x00 8. "    CRME                         ,cr7 ddr remap enable   0 = cr7 ddr remap disabled 1 = cr7 ddr remap enabled" "0,1"
        bitfld.long 0x00 0.--4. "       CRMADDR                  ,cr7 ddr remap address.    when cr7 ddr remap is enabled, cr7 ddr address [32:28] is replaced with crmaddr[4:0] in this field" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31"

tree.end

tree "apbclock"

width 25.

group d:0xD4015000++0x03
    line.long 0x00 "APBC_UART1_CLK_RST,Clock/Reset Control Register for UART 1"
        bitfld.long 0x00 4.--6. " FNCLKSEL15          ,functional clock select  0x0 = 58.5 mhz  0x1 = 14.7456 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST17        ,uart reset generation  this field resets both apb and functional domains.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK18      ,uart functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK19  ,uart  apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015004++0x03
    line.long 0x00 "APBC_UART2_CLK_RST,Clock/Reset Control Register for UART 2"
        bitfld.long 0x00 4.--6. " FNCLKSEL27          ,functional clock select  0x0 = 58.5 mhz  0x1 = 14.7456 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST29        ,uart reset generation  this field resets both apb and functional domains.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK30      ,uart functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK31  ,uart  apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015008++0x03
    line.long 0x00 "APBC_GPIO_CLK_RST,Clock/Reset Control Register for GPIO"
        bitfld.long 0x00 4.--6. " FNCLKSEL39          ,functional clock select  0x0 to 0x7 = no clock" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST41        ,gpio reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK42      ,gpio functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK43  ,gpio apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD401500C++0x03
    line.long 0x00 "APBC_PWM0_CLK_RST,Clock/Reset Control Register for PWM 0"
        bitfld.long 0x00 4.--6. " FNCLKSEL52          ,functional clock select  0x0 = 13 mhz  0x1 = 32 khz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST54        ,pwm 0 reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK55      ,pwm 0 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK56  ,pwm 0/1 apb bus clock enable/disable  0 = clock off  1 = clock on. this bit controls the apb clocks for both pwm0 and pwm1." "0,1"

group d:0xD4015010++0x03
    line.long 0x00 "APBC_PWM1_CLK_RST,Clock/Reset Control Register for PWM 1"
        bitfld.long 0x00 4.--6. " FNCLKSEL65          ,functional clock select  0x0 = 13 mhz  0x1 = 32 khz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST67        ,pwm 1 reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK68      ,pwm 1 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015014++0x03
    line.long 0x00 "APBC_PWM2_CLK_RST,Clock/Reset Control Register for PWM 2"
        bitfld.long 0x00 4.--6. " FNCLKSEL78          ,functional clock select  0x0 = 13 mhz  0x1 = 32 khz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST80        ,pwm 2 reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK81      ,pwm 2 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK82  ,pwm 2/3 apb bus clock enable/disable  0 = clock off  1 = clock on. this bit controls the apb clocks for both pwm2 and pwm3." "0,1"

group d:0xD4015018++0x03
    line.long 0x00 "APBC_PWM3_CLK_RST,Clock/Reset Control Register for PWM 3"
        bitfld.long 0x00 4.--6. " FNCLKSEL91          ,functional clock select  0x0 = 13 mhz  0x1 = 32 khz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST93        ,pwm 3 reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK94      ,pwm 3 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD401501C++0x03
    line.long 0x00 "APBC_SSP0_CLK_RST,Clock/Reset Control Register for SSP 0"
        bitfld.long 0x00 7. " SEL_SSP_FUNC_CLK104 ,ac97 clock switch  this bit enables the ssp module to switch clocks internally." "0,1"
        bitfld.long 0x00 4.--6. "     FNCLKSEL105  ,functional clock select  0x0 = 6.5 mhz  0x1 = 13 mhz  0x2 = 26 mhz  0x3 = 52 mhz   0x4 = 3.25 mhz  0x5 = 1.625 mhz  0x6 = 812.5 khz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "  RST107       ,ssp 0 reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK108  ,ssp 0 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        textline "                                   "
        bitfld.long 0x00 0. "APBCLK109           ,ssp 0 apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015024++0x03
    line.long 0x00 "APBC_IPC_CLK_RST,Clock/Reset Control Register for Inter-Processor Communication"
        bitfld.long 0x00 4.--6. " FNCLKSEL119         ,functional clock select  all values = no clock" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST121       ,inter-processor communication (ipc) reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK122     ,ipc functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK123 ,ipc apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015028++0x03
    line.long 0x00 "APBC_RTC_CLK_RST,Clock/Reset Control Register for RTC"
        bitfld.long 0x00 7. " PM_POWER_SENSOR     ,power enabled  this field enables the register read/writes for the rtc module by indicating power enable. set this field to 0x1 before enabling rtc operations." "0,1"
        bitfld.long 0x00 4.--6. "     FNCLKSEL132  ,functional clock select  0x0 = 32 khz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "  RST134       ,rtc reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK135  ,rtc functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        textline "                                   "
        bitfld.long 0x00 0. "APBCLK136           ,rtc apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD401502C++0x03
    line.long 0x00 "APBC_TWSI0_CLK_RST,Clock/Reset Control Register for TWSI0"
        bitfld.long 0x00 4.--6. " FNCLKSEL144         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST146       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK147     ,twsi0 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK148 ,twsi0 apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015030++0x03
    line.long 0x00 "APBC_KPC_CLK_RST,Clock/Reset Control Register for Keypad Controller"
        bitfld.long 0x00 4.--6. " FNCLKSEL156         ,functional clock select  0x0 = 32 khz  0x1 = 16 khz  0x2 = 26 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST158       ,keypad controller reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK159     ,keypad controller functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK160 ,keypad controller apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015034++0x03
    line.long 0x00 "APBC_TIMERS_CLK_RST,Clock/Reset Control Register for Timer 0"
        bitfld.long 0x00 4.--6. " FNCLKSEL168         ,functional clock select  0x0 = 13 mhz  0x1 = 32 khz  0x2 = 6.5 mhz  0x3 = 3.25 mhz  0x4 = 1 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST170       ,timers reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK171     ,timers functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK172 ,timers apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD401503C++0x03
    line.long 0x00 "APBC_AIB_CLK_RST,Clock/Reset Control Register for AIB"
        bitfld.long 0x00 4.--6. " FNCLKSEL180         ,functional clock select  all values = no clock" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST182       ,aib reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK183     ,aib functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK184 ,aib apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015040++0x03
    line.long 0x00 "APBC_SW_JTAG_CLK_RST,Clock/Reset Control Register for JTAG Software Emulation"
        bitfld.long 0x00 4.--6. " FNCLKSEL192         ,functional clock select  all values = no clock" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST194       ,jtag software emulation reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK195     ,jtag software emulation functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK196 ,jtag software emulation apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015044++0x03
    line.long 0x00 "APBC_TIMERS1_CLK_RST,Clock/Reset Control Register for Timers 1"
        bitfld.long 0x00 4.--6. " FNCLKSEL204         ,functional clock select  0x0 = 13 mhz  0x1 = 32 khz  0x2 = 6.5 mhz  0x3 = 3.25 mhz  0x4 = 1 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST206       ,timers 1 reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK207     ,timers 1 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK208 ,timers 1 apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015048++0x03
    line.long 0x00 "APBC_ONEWIRE_CLK_RST,Clock/Reset Control Register for One-Wire"
        bitfld.long 0x00 4.--6. " FNCLKSEL216         ,functional clock select  all values = no clock" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST218       ,one-wire reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK219     ,one-wire functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK220 ,one-wire apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD401504C++0x03
    line.long 0x00 "APBC_SSP2_CLK_RST,Clock/Reset Control Register for SSP 2"
        bitfld.long 0x00 7. " SEL_SSP_FUNC_CLK229 ,ac97 clock switch  this bit enables the ssp module to switch clocks internally." "0,1"
        bitfld.long 0x00 4.--6. "     FNCLKSEL230  ,functional clock select  0x0 = 6.5 mhz  0x1 = 13 mhz  0x2 = 26 mhz  0x3 = 52 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "  RST232       ,ssp 2 reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK233  ,ssp 2 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        textline "                                   "
        bitfld.long 0x00 0. "APBCLK234           ,ssp 2 apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015050++0x03
    line.long 0x00 "APBC_ASFAR,AIB Secure First Access Register"
        hexmask.long.word 0x00 0.--15. 1. " ASFAR               ,first access key  writing the value of 0xbaba to this register will match the key. this register will get cleared to 0x0 when one secure access is completed."

group d:0xD4015054++0x03
    line.long 0x00 "APBC_ASSAR,AIB Secure Second Access Register"
        hexmask.long.word 0x00 0.--15. 1. " ASSAR               ,section access key  writing the value of 0xeb10 to this register will match the key. this register will get cleared to 0x0 when one secure access is completed."

group d:0xD4015060++0x03
    line.long 0x00 "APBC_TWSI1_CLK_RST,Clock/Reset Control Register for TWSI1"
        bitfld.long 0x00 4.--6. " FNCLKSEL258         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST260       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK261     ,twsi functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK262 ,twsi apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015064++0x03
    line.long 0x00 "APBC_COUNTER_CLK_SEL,Clock Control Register for Generic Counter"
        hexmask.long.word 0x00 16.--31. 1. " LOW_FREQ_STEP       ,generic counter step of low frequency  under low frequency, this is the generic counter step value.  its default is 26 mhz/32768 = 0x319"
        bitfld.long 0x00 1. "  FREQ_SW_SEL  ,generic counter frequency software select  if freq_hw_en = 0 generic counter clock frequency select  0x0 = 26 mhz  1 = 32 khz" "0,1"
        bitfld.long 0x00 0. "  FREQ_HW_CTRL ,generic counter frequency controlled by hardware  0x0 = software freq_sw_sel bit  1 = hardware vctcxo_en signal  if vctcxo_en = 1, generic counter clock frequency is 26 mhz  if  vctcxo_en = 0, generic counter clock frequency is 32 khz" "0,1"

group d:0xD4015068++0x03
    line.long 0x00 "APBC_TIMERS2_CLK_RST,Clock/Reset Control Register for Timers 2"
        bitfld.long 0x00 4.--6. " FNCLKSEL281         ,functional clock select  0x0 = 13 mhz  0x1 = 32 khz  0x2 = 6.5 mhz  0x3 = 3.25 mhz  0x4 = 1 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST283       ,timers 1 reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK284     ,timers 1 functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK285 ,timers 1 apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD401506C++0x03
    line.long 0x00 "APBC_TSEN_CLK_RST,Clock/Reset Control Register for Temperature Sensor"
        bitfld.long 0x00 2. " TSEN_RST_EN         ,temperature sensor reset enable  0x0 = release reset  0x1 = reset temperature sensor" "0,1"
        bitfld.long 0x00 1. "     TSEN_FCLK_EN ,temperature sensor function clock enable  0x0 = disable temperature sensor function clock  1 = enable temperature sensor function clock" "0,1"
        bitfld.long 0x00 0. "  TSEN_PCLK_EN ,temperature sensor apb clock enable  0x0 = disable temperature sensor apb clock  1 = enable temperature sensor apb clock" "0,1"

group d:0xD4015070++0x03
    line.long 0x00 "APBC_TWSI2_CLK_RST,Clock/Reset Control Register for TWSI2"
        bitfld.long 0x00 4.--6. " FNCLKSEL303         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST305       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK306     ,twsi functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK307 ,twsi apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015074++0x03
    line.long 0x00 "APBC_TWSI3_CLK_RST,Clock/Reset Control Register for TWSI3"
        bitfld.long 0x00 4.--6. " FNCLKSEL315         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST317       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK318     ,twsi functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK319 ,twsi apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015078++0x03
    line.long 0x00 "APBC_UART3_CLK_RST,Clock/Reset Control Register for UART 3"
        bitfld.long 0x00 4.--6. " FNCLKSEL327         ,functional clock select  0x0 = 58.5 mhz  0x1 = 14.7456 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST329       ,uart reset generation  this field resets both apb and functional domains.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK330     ,uart functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK331 ,uart  apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD401507C++0x03
    line.long 0x00 "APBC_TWSI4_CLK_RST,Clock/Reset Control Register for TWSI4"
        bitfld.long 0x00 4.--6. " FNCLKSEL339         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST341       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK342     ,twsi functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK343 ,twsi apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015080++0x03
    line.long 0x00 "APBC_TWSI5_CLK_RST,Clock/Reset Control Register for TWSI5"
        bitfld.long 0x00 4.--6. " FNCLKSEL351         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST353       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK354     ,twsi functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK355 ,twsi apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015084++0x03
    line.long 0x00 "APBC_TWSI6_CLK_RST,Clock/Reset Control Register for TWSI6"
        bitfld.long 0x00 4.--6. " FNCLKSEL363         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST365       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK366     ,twsi functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK367 ,twsi apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015088++0x03
    line.long 0x00 "APBC_TWSI7_CLK_RST,Clock/Reset Control Register for TWSI7"
        bitfld.long 0x00 4.--6. " FNCLKSEL375         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST377       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK378     ,twsi functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK379 ,twsi apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD401508C++0x03
    line.long 0x00 "APBC_TWSI8_CLK_RST,Clock/Reset Control Register for TWSI8"
        bitfld.long 0x00 4.--6. " FNCLKSEL387         ,functional clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  all other values = reserved, do not use" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST389       ,twsi reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK390     ,twsi functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK391 ,twsi apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

group d:0xD4015090++0x03
    line.long 0x00 "APBC_IPC_AP2AUD_CLK_RST,Clock/Reset Control Register for Inter-Processor Communication（AP to Audio）"
        bitfld.long 0x00 4.--6. " FNCLKSEL399         ,functional clock select  all values = no clock" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 2. "     RST401       ,inter-processor communication (ipc) reset generation  this field resets both the apb and functional domain.  0 = no reset  1 = reset" "0,1"
        bitfld.long 0x00 1. "  FNCLK402     ,ipc functional clock enable/disable  0 = clock off  1 = clock on" "0,1"
        bitfld.long 0x00 0. "  APBCLK403 ,ipc apb bus clock enable/disable  0 = clock off  1 = clock on" "0,1"

tree.end

tree "apbcontrol"

width 13.

group d:0xD023B000++0x03
    line.long 0x00 "TCTS,TCU Clock Trigger Control Register"
        bitfld.long 0x00 0. " TCU_CLOCK_TRIGGER_SELECT        ,tcu clock trigger select  1 = trigger from wideband  0 = trigger from slow clock" "0,1"

group d:0xD023B004++0x03
    line.long 0x00 "THALT,TCU HALT Mode Control Register"
        bitfld.long 0x00 0. " TCU_HALT_MODE_SELECT            ,tcu halt mode select  1 = on  0 = off" "0,1"

group d:0xD023B00C++0x03
    line.long 0x00 "GBS,GSSP Bus Interface Select Register"
        bitfld.long 0x00 0. " GSSP_BUS_SELECT                 ,gssp bus select  this field selects which bus connects to the gssp.  1 = apb  0 = gpb" "0,1"

group d:0xD023B010++0x03
    line.long 0x00 "APB_GAMPMCR,APB CP Peripherals Monitor Control Register"
        bitfld.long 0x00 29.--31. " TEST_POINT_OUTPUT_SELECT        ,test point output select  this field selects which test points to output. it selects one of eight possible test point combinations.  default = 0" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 16. "   38                      ,enable apb peripheral monitor  1 = enable  0 = disable all monitoring  default = 0" "0,1"
        bitfld.long 0x00 12.--15. "   39                      ,bits [31:24] in monitor mux output select  0x0 = e-cipher  0x1 = airq  0x2 = tcu  0x3 = usim 1  0x4 = usim 2  0x5 = uart  0x6 = twsi  0x7 = gssp   0x8 = timers  all other values are reserved.  default = 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "  40                    ,bits [23:16] in monitor mux output select  0x0 = e-cipher  0x1 = airq  0x2 = tcu  0x3 = usim 1  0x4 = usim 2  0x5 = uart  0x6 = twsi  0x7 = gssp   0x8 = timers  all other values are reserved.  default = 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                       "
        bitfld.long 0x00 4.--7. "41                              ,bits [15:8] in monitor mux output select  0x0 = e-cipher  0x1 = airq  0x2 = tcu  0x3 = usim 1  0x4 = usim 2  0x5 = uart  0x6 = twsi  0x7 = gssp   0x8 = timers  all other values are reserved.  default = 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "  42                      ,bits [7:0] in monitor mux output select  0x0 = e-cipher  0x1 = airq  0x2 = tcu  0x3 = usim 1  0x4 = usim 2  0x5 = uart  0x6 = twsi  0x7 = gssp   0x8 = timers  all other values are reserved.  default = 0" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD023B014++0x03
    line.long 0x00 "TCER,TCU Clock Control Register"
        bitfld.long 0x00 2. " SW_RESET50                      ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE51          ,clock enable  0 = off  1 = on" "0,1"

group d:0xD023B018++0x03
    line.long 0x00 "ACER,AIRQ Clock Control Register"
        bitfld.long 0x00 2. " SW_RESET60                      ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE61          ,clock enable  0 = off  1 = on" "0,1"

group d:0xD023B01C++0x03
    line.long 0x00 "UCER,UART Clock Control Register"
        bitfld.long 0x00 2. " SW_RESET70                      ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE71          ,clock enable  0 = off  1 = on" "0,1"
        bitfld.long 0x00 0. "   BUS_CLOCK_ENABLE72      ,bus clock enable  0 = off  1 = on" "0,1"

group d:0xD023B020++0x03
    line.long 0x00 "USCER1,USIM 1 Clock Control Register"
        bitfld.long 0x00 2. " SW_RESET80                      ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE81          ,clock enable  0 = off  1 = on" "0,1"
        bitfld.long 0x00 0. "   BUS_CLOCK_ENABLE82      ,bus clock enable  0 = off  1 = on" "0,1"

group d:0xD023B024++0x03
    line.long 0x00 "USCER2,USIM 2 Clock Control Register"
        bitfld.long 0x00 2. " SW_RESET90                      ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE91          ,clock enable  0 = off  1 = on" "0,1"
        bitfld.long 0x00 0. "   BUS_CLOCK_ENABLE92      ,bus clock enable  0 = off  1 = on" "0,1"

group d:0xD023B028++0x03
    line.long 0x00 "ICER,TWSI Clock Control Register"
        bitfld.long 0x00 3.--4. " FN_SEL                          ,clock select  0x0 = 32 mhz  0x1 = 52 mhz  0x2 = 62.4 mhz  0x03 = 62.4 mhz" "0,1,2,3"
        bitfld.long 0x00 2. "   SW_RESET101             ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE102         ,clock enable  0 = off  1 = on" "0,1"
        bitfld.long 0x00 0. "   BUS_CLOCK_ENABLE103   ,bus clock enable  0 = off  1 = on" "0,1"

group d:0xD023B02C++0x03
    line.long 0x00 "ECCER,APB E-Cipher Clock Control Register"
        bitfld.long 0x00 2. " SW_RESET111                     ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE112         ,clock enable  0 = off  1 = on" "0,1"

group d:0xD023B030++0x03
    line.long 0x00 "TICER,APB Timers Clock Control Register"
        bitfld.long 0x00 2. " SW_RESET121                     ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE122         ,clock enable  0 = off  1 = on" "0,1"
        bitfld.long 0x00 0. "   BUS_CLOCK_ENABLE123     ,bus clock enable  0 = off  1 = on" "0,1"

group d:0xD023B034++0x03
    line.long 0x00 "GCER,GSSP Clock Control Register"
        bitfld.long 0x00 8.--9. " GSSP1_CLOCK_SEL                 ,gssp1 clock select  0x0 = i<super 2>s clk  0x1 = sys clk  0x2 = ext clk  0x3 = 26 mhz" "0,1,2,3"
        bitfld.long 0x00 6.--7. "   GSSP2_CLOCK_SEL         ,gssp2 clock select  0x0 = i<super 2>s clk  0x1 = sys clk  0x2 = ext clk  0x3 = 26 mhz" "0,1,2,3"
        bitfld.long 0x00 5. "   APBCO_GSSP2_SW_RESET133 ,gssp2 software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 4. "   GSSP2_CLOCK_ENABLE    ,gssp2 clock enable  0 = off  1 = on" "0,1"
        textline "                       "
        bitfld.long 0x00 3. "APBCO_GSSP2_BUS_CLOCK_ENABLE135 ,gssp2_bus clock enable  0 = off  1 = on" "0,1"
        bitfld.long 0x00 2. "   APBCO_GSSP1_SW_RESET136 ,gssp1 software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   GSSP1_CLOCK_ENABLE      ,gssp1 clock enable  0 = off  1 = on" "0,1"
        bitfld.long 0x00 0. "   GSSP1BUS_CLOCK_ENABLE ,gssp1 bus clock enable  0 = off  1 = on" "0,1"

group d:0xD023B038++0x03
    line.long 0x00 "AICER,IPC/RIPC Clock Control Register"
        bitfld.long 0x00 2. " SW_RESET146                     ,software reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE147         ,clock enable  0 = off  1 = on" "0,1"

group d:0xD023B03C++0x03
    line.long 0x00 "SCCR,Slow Clock Clock Control Register"
        bitfld.long 0x00 4. " 156                             ,gsm slow-clock (sck) functional clock frequency select  this register is not used.  sck receives a fixed 26-mhz clock." "0,1"
        bitfld.long 0x00 2. "   SW_RESET158             ,sw reset  0 = normal operation  1 = reset peripheral" "0,1"
        bitfld.long 0x00 1. "   CLOCK_ENABLE160         ,clock enable  0 = off  1 = on  this register is not used  sck receives the low-power 26-mhz clock controlled by m regs" "0,1"

tree.end

tree "pmucp"

width 22.

group d:0xD0201800++0x03
    line.long 0x00 "STIKY_CLR0,AIRQ Interrupt Clear 0 Register"
        hexmask.long 0x00 0.--31. 1. " CP_PM_AIRQ_INT_CLR_013      ,airq interrupt clear 0  to clear the interrupt sticky-bit, write 1.  there is no need to write 0, since the register clears itself (one-shot).  when level interrupt function is selected, these registers have no effect.  bit [0] refers to interrupt 0, bit [1] refers to interrupt 1, etc."

group d:0xD0201804++0x03
    line.long 0x00 "STIKY_CLR1,AIRQ Interrupt Clear 1 Register"
        hexmask.long 0x00 0.--31. 1. " CP_PM_AIRQ_INT_CLR_121      ,airq interrupt clear 1  to clear the interrupt sticky-bit, write 1.  there is no need to write 0, since the register clears itself (one-shot).  when level interrupt function is selected, these registers have no effect.  bit [0] refers to interrupt 32, bit [1] refers to interrupt 33, etc."

group d:0xD0201808++0x03
    line.long 0x00 "EDGE_OR_LEVEL0,AIRQ Interrupt Sensitivity 0 Register"
        hexmask.long 0x00 0.--31. 1. " CP_PM_AIRQ_EDGE_LEVEL_029   ,airq edge level 0  0 = originally level-sensitive interrupt (no sticky bit needed)  1 = originally edge-sensitive interrupt (sticky bit needed)  bit [0] refers to interrupt 0, bit [1] refers to interrupt 1, etc."

group d:0xD020180C++0x03
    line.long 0x00 "EDGE_OR_LEVEL1,AIRQ Interrupt Sensitivity 1 Register"
        hexmask.long 0x00 0.--31. 1. " CP_PM_AIRQ_EDGE_LEVEL_137   ,airq edge level 1  0 = originally level-sensitive interrupt (no sticky bit needed)  1 = originally edge-sensitive interrupt (sticky bit needed)  bit [0] refers to interrupt 32, bit [1] refers to interrupt 33, and so on."

group d:0xD0201810++0x03
    line.long 0x00 "EDGE_OR_LEVEL2,AIRQ Interrupt Sensitivity 1 Register"
        hexmask.long.word 0x00 0.--15. 1. " AIRQ_EDGE_LEVEL_2           ,airq edge level 1  0 = originally level-sensitive interrupt (no sticky bit needed)  1 = originally edge-sensitive interrupt (sticky bit needed)  bit [0] refers to interrupt 64, bit [1] refers to interrupt 65, and so on."

group d:0xD0201818++0x03
    line.long 0x00 "STIKY_CLR2,AIRQ Interrupt Clear 2 Register"
        hexmask.long.word 0x00 0.--15. 1. " AIRQ_INT_CLR_2              ,airq interrupt clear 1  to clear the interrupt sticky-bit, write 1.  there is no need to write 0, since the register clears itself (one-shot).  when level interrupt function is selected, these registers have no effect.  bit [0] refers to interrupt 64, bit [1] refers to interrupt 65, etc."

group d:0xD0201820++0x03
    line.long 0x00 "DDR_REQ_CTRL_SG,DDR Request Control Register for <var Processor: Comm>"
        bitfld.long 0x00 31. " DDRC_RDY_EN61               ,  1 = 1= axi transactions to ddrc are sent without considering ddrc's status   0 =  0= axi transactions to ddrc are only sent when ddrc is ready" "0,1"
        hexmask.long.word 0x00 21.--30. 1. "         CP_PM_62                     ,"
        bitfld.long 0x00 20. "      FBDMA_DDRC_REQ_EN63            ,  0x1= if fb dma is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because fb dma's is active" "0,1"
        bitfld.long 0x00 19. "     DTC_DDRC_REQ_EN64                 ,  0x1= if dtc is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because dtc's is active" "0,1"
        textline "                                "
        bitfld.long 0x00 18. "CPDMA_DDRC_REQ_EN65         ,  0x1= if cp dma is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because cp dma is actvie" "0,1"
        bitfld.long 0x00 17. "         MSA_DDRC_REQ_EN66            ,  0x1= if msa is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because msa is active" "0,1"
        bitfld.long 0x00 16. "         SG_DDRC_REQ_EN67               ,  0x1= if <var processor: comm> is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because <var processor: comm> is active" "0,1"
        bitfld.long 0x00 15. "     GSM_DDRC_REQ_EN68                 ,  0x1= if gsm is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because gsm is active" "0,1"
        textline "                                "
        bitfld.long 0x00 14. "CP_PM_69                    ," "0,1"
        bitfld.long 0x00 13. "         FB_MODEM_DDRC_REQ_EN70       ,  0x1= if modem is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because modem is active" "0,1"
        bitfld.long 0x00 12. "         PWR_MODE_DDRC_REQ_EN71         ,  0x1= if pwr_mode is 2'b00, request ddrc resource<p>0x0 = ddrc resource will not be requested because pwr_mode is 2'b00" "0,1"
        hexmask.long.byte 0x00 4.--11. 1. "     CP_PM_72                          ,"
        textline "                                "
        bitfld.long 0x00 3. "DTCMSD73                    ,ddr is ready for cp access   1 = ddr is ready <0>ddr is not ready" "0,1"
        bitfld.long 0x00 0.--2. "         CP_PM_74                     ," "0,1,2,3,4,5,6,7"

group d:0xD0201824++0x03
    line.long 0x00 "SG_SLEEP_CTRL,<var Processor: Comm> Sleep Control Register"
        bitfld.long 0x00 31. " WAKEUP_GLOBAL_MASK          ,0 =  enable wakeup source; 1 = cp wakeup source disabled. this bit should be set before issue wfi with sg_idle_cfg[1 or 0] set, and it will be auto-cleared after cp enters either external_clock_gating or power_down mode" "0,1"
        bitfld.long 0x00 30. "         WAKEUP_GLOBAL_MASK2          ,0 =  enable wakeup source; 1 = cp wakeup source disabled. this bit should be set before issue wfi with sg_idle_cfg[1 or 0] set, and it will be auto-cleared after cp enters either external_clock_gating or power_down mode. this is intended to be used with firq, but are not needed right now." "0,1"
        hexmask.long.word 0x00 16.--29. 1. "         CP_PM_84                       ,"
        hexmask.long.word 0x00 0.--15. 1. "  CP_PM_85                          ,reserved for future use"

group d:0xD0201828++0x03
    line.long 0x00 "MSA_RST,MSA Reset Register"
        bitfld.long 0x00 31. " MSA_IDLE                    ,msa in idle or not   0x1=msa is in idle" "0,1"
        bitfld.long 0x00 29.--30. "         MSA_LPM_VOTE                 ,msa vote for sleep,   0x0= normal   0x1=d2 mode   0x2=d2 with control from modem  11= reserved" "0,1,2,3"
        bitfld.long 0x00 28. "         FB_DMA_BUSY                    ,fb dma is busy or not" "0,1"
        bitfld.long 0x00 3. "     MSA_RST_STATUS                    ,msa reset status    0x0= msa is released from reset   0x1= msa is in reset" "0,1"
        textline "                                "
        bitfld.long 0x00 2. "MSA_SILENT_RST_MODE         ,enable or disable silent reset mode. combined to be used with bit1.   0x0=silent reset mode is disabled   0x1=silent reset mode is enabled" "0,1"
        bitfld.long 0x00 1. "         MSA_SW_RST                   ,msa software reset. write 1 to this bit to reset msa subsystem   0x0=release msa subsystem from reset   0x1=reset msa subsystem.when bit2 is 1, silent reset msa subsystem. when bit2 is 0, immediate reset msa subsystem" "0,1"
        bitfld.long 0x00 0. "         MSA_RST_HOLD                   ,reset hold control upon wakeup   =0x0 msa will be released from reset after wakeup   =0x1 msa will be hold in reset state after wakeup" "0,1"

group d:0xD020182C++0x03
    line.long 0x00 "SG_INT_REG,<var Processor: Comm> interrupt selection register"
        hexmask.long 0x00 2.--31. 1. " CP_PM_106                   ,"
        bitfld.long 0x00 1. "  CP_PM_107                    ,when this bit is 1,mark the frq to <var processor: comm> from airq" "0,1"
        bitfld.long 0x00 0. "         CP_PM_108                      ,when this bit is 1, mark the irq to <var processor: comm> from airq" "0,1"

group d:0xD0201834++0x03
    line.long 0x00 "CPSS_HW_GATE_CTRL_SG,CPSS Hardware Clock Gating Control for <var Processor: Comm>"
        hexmask.long.word 0x00 23.--31. 1. " CP_PM_116                   ,reserved"
        bitfld.long 0x00 22. "      CP_PM_117                    ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 21. "         CP_PM_118                      ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 20. "     CP_PM_119                         ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        textline "                                "
        bitfld.long 0x00 19. "CP_PM_120                   ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 18. "         CP_PM_121                    ,not used" "0,1"
        bitfld.long 0x00 17. "         CP_PM_122                      ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 16. "     CP_PM_123                         ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        textline "                                "
        bitfld.long 0x00 15. "CP_PM_124                   ,reserved" "0,1"
        bitfld.long 0x00 14. "         CP_PM_125                    ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 13. "         CP_PM_126                      ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 12. "     CP_PM_127                         ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        textline "                                "
        bitfld.long 0x00 11. "CP_PM_128                   ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 10. "         CP_PM_129                    ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 9. "         CP_PM_130                      ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 8. "     CP_PM_131                         ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        textline "                                "
        bitfld.long 0x00 7. "CP_PM_132                   ,reserved" "0,1"
        bitfld.long 0x00 6. "         CP_PM_133                    ,reserved" "0,1"
        bitfld.long 0x00 5. "         CP_PM_134                      ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 4. "     CP_PM_135                         ,not used" "0,1"
        textline "                                "
        bitfld.long 0x00 3. "CP_PM_136                   ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 2. "         CP_PM_137                    ,must be set to 1 or deadlock" "0,1"
        bitfld.long 0x00 1. "         CP_PM_138                      ,   0x1= clock enabled    0x0= clock disabled" "0,1"
        bitfld.long 0x00 0. "     CP_PM_139                         ,must be set to 1 or deadlock" "0,1"

group d:0xD0201838++0x03
    line.long 0x00 "AP_status_reg,AP FSM Status Register"
        bitfld.long 0x00 31. " CP_PM_146                   ,1 is audio on" "0,1"
        hexmask.long 0x00 6.--30. 1. "         CP_PM_147                    ,"
        hexmask.long.byte 0x00 0.--5. 1. "  CP_PM_148                      ,the power status for ap-:  bit [5] is always '0' 0: ap reset, 1: idle(normal operation) 5'b01011:wakup sp, 2: dma idle, 4: disable bus, 5: clock gate, 3: memory controller idle, 7: ap sleep, 5'b10011: ap d2"

group d:0xD0201848++0x03
    line.long 0x00 "SG__TIMER,<var Processor: Comm>  Timer Register"
        hexmask.long.byte 0x00 16.--23. 1. " CP_PM_PWR_CLK_PRE156        ,clock divider prescaler for the timer count.  0 = divider by one.  1 = divide by 1.  2= divider by 2.>p> rest incremental divider."
        hexmask.long.byte 0x00 8.--15. 1. "        CP_PM_PWR_UP_STBL_TIMER157   ,power up stable timer  stable time for the power up during core idle mode in 26 mhz unit"
        hexmask.long.byte 0x00 0.--7. 1. "        CP_PM_PWR_DWN_STBL_TIMER158    ,power down stable timer  stable time for the power down during core idle mode in 26 mhz unit"

group d:0xD020184C++0x03
    line.long 0x00 "SG_IDLE_CFG,<var Processor: Comm> Idle  Configuration Register"
        bitfld.long 0x00 20.--21. " CP_PM_PSW_MODE166           ,cr5 core has both big macro power switch and distributed power switch. this field select different power swith mode    2'b00 both big macro switches and distributed switches will be used. during power up – first power up the big macro switches followed by distributed switches.during power down – first power down the distributed switches followed by big macro switches.    2'b01 only big macro switch is used. distributed switches will be permanently shut off    2'b10 only distributed switches in the core is used and big macro switches will be off. distributed switches turn on simultaneously which will cause a big power surge. to reduce the power surge, first turn on all the big macro switches, then turn on distributed switches and finally turn off the big macro switches leaving only the distributed switches on" "0,1,2,3"
        bitfld.long 0x00 19. "         DIS_CORE_L2_SLP              ,disable the core l2 sram power switch sleep power down during core power down mode.  1 = disable core l2 power switch sleep." "0,1"
        bitfld.long 0x00 18. "         CP_PM_DIS_CORE_L1_SLP168       ,disable the core l1 sram power switch sleep power down during core power down mode.  1 = disable core l1 power switch sleep." "0,1"
        bitfld.long 0x00 17. "     CP_PM_DIS_CORE_SLP169             ,disable the core power switch sleep power down during core power down mode.  1 = disable core power switch sleep" "0,1"
        textline "                                "
        bitfld.long 0x00 11. "CP_PM_MASK_CLK_OFF_CHECK171 ,mask core clock off  check during core idle process." "0,1"
        bitfld.long 0x00 10. "         CP_PM_MASK_CLK_STBL_CHECK172 ,mask core clock stable check during core wakeup." "0,1"
        bitfld.long 0x00 9. "         CP_PM_MASK_JTAG_IDLE_CHECK173  ,mask the jtag idle check during mp idle entry   1 = mask the jtag idle check." "0,1"
        bitfld.long 0x00 8. "     CP_PM_MASK_CORE_WFI_IDLE_CHECK174 ,debug only - it should be 0 during normal opration mask core wfi idle check   1 = status check masked  0 = status check not masked" "0,1"
        textline "                                "
        bitfld.long 0x00 5. "CP_PM_DIS_MC_SW_REQ176      ,disable the mc entry to idle mode using the mc sleep request bits. mc will always enter into idle mode based on the hardware sm request.  0 = enable the idle entry using sw register bits.  1 = disable the idle entry using the sw register bits." "0,1"
        bitfld.long 0x00 4. "         CP_PM_SEA_MC_WAKE_EN177      ,wake up the mc when <var processor: comm> wake up from core idle mode. mc will be waked up before the interrupt to the core is released.  0 = mc wake disabled.  1 = mc wake up enabled on <var processor: comm> wake." "0,1"
        bitfld.long 0x00 3. "         CORE_L2_SRAM_PWRDWN            ,l2 is powered off or not when core is powered off <0> l2 is retained <1> l2 is powered off" "0,1"
        bitfld.long 0x00 2. "     CP_PM_CORE_L1_SRAM_PWRDWN179      ,l1 is powered off or not when core is powered off <0> l1 is retained <1> l1 is powered off" "0,1"
        textline "                                "
        bitfld.long 0x00 1. "CP_PM_CORE_PWRDWN180        ,core power down. this bit does not takes effect if core_idle is 0.   1 = when core issue wfi idle, core will go into deep sleep mode and power will be turned off. this bit will not take effect  if cap dbgnopwrdwn is set" "0,1"
        bitfld.long 0x00 0. "         CP_PM_CORE_IDLE181           ,core idle  1 = when core issue wfi idle, the core clock will be gated externally. this bit will not take effect if cr5 dbgnopwrdwn is set" "0,1"

group d:0xD0201870++0x03
    line.long 0x00 "AXISD_HW_SG,AXISD HW Control Register"
        hexmask.long.tbyte 0x00 8.--31. 1. " CP_PM_279                   ,"
        bitfld.long 0x00 7. "    SG_AXISD_CTRL280             ,hardware voting control for axisd   0x1= if <var processor: comm> is active, do not allow axi shut down<p>0x0 = do not care <var processor: comm>'s status" "0,1"
        bitfld.long 0x00 6. "         MSA_AXISD_CTRL281              ,hardware voting control for axisd   0x1= if msa is active, do not allow axi shut down<p>0x0 = do not care msa's status" "0,1"
        bitfld.long 0x00 5. "     CP_DMAC_AXISD_CTRL282             ,hardware voting control for axisd   0x1= if cp dmac is active, do not allow axi shut down<p>0x0 = do not care cp dmac's status" "0,1"
        textline "                                "
        bitfld.long 0x00 4. "DTC_AXISD_CTRL283           ,hardware voting control for axisd   0x1= if dtc is active, do not allow axi shut down<p>0x0 = do not care dtc's status" "0,1"
        bitfld.long 0x00 3. "         PWR_MODE_AXISD_CTRL284       ,hardware voting control for axisd   0x1= if pwr_mode is 2'b00, do not allow axi shut down<p>0x0 = do not care pwr_mode" "0,1"
        bitfld.long 0x00 2. "         FB_DMAC_AXISD_CTRL285          ,hardware voting control for axisd   0x1= if fb dmac is active, do not allow axi shut down<p>0x0 = do not care fb dmac's status" "0,1"
        bitfld.long 0x00 1. "     FB_AXISD_CTRL286                  ,hardware voting control for axisd   0x1= if fb modem is active, do not allow axi shut down<p>0x0 = do not care fb modem's status" "0,1"
        textline "                                "
        bitfld.long 0x00 0. "GSM_AXISD_CTRL287           ,hardware voting control for axisd   0x1= if gsm is active, do not allow axi shut down<p>0x0 = do not care gsm's status" "0,1"

group d:0xD0201874++0x03
    line.long 0x00 "CP_ACLKDIV_HW_CTRL,CPSS Fabric ACLK Clock Divider HW Control"
        hexmask.long 0x00 4.--31. 1. " CP_PM_294                   ,"
        bitfld.long 0x00 3. "  SW_ACLKDIV_DIS_VOTE          ,cp fabric clock divider auto disable sw    0x1 = sw allow cp fabric clock divider to be automatically disabled by hw     0x0 = sw disallow cp fabric clock divider to be automatically disabled by hw" "0,1"
        bitfld.long 0x00 2. "         CPDMA_ACLKDIV_DIS_VOTE         ,cp fabric clock divider auto disable when msa is c2/d2    0x1 = when seagull is in c2/d2, cp fabric clock divider is automatically disabled" "0,1"
        bitfld.long 0x00 1. "     MSA_ACLKDIV_DIS_VOTE              ,cp fabric clock divider auto disable when msa is c2/d2    0x1 = when seagull is in c2/d2, cp fabric clock divider is automatically disabled" "0,1"
        textline "                                "
        bitfld.long 0x00 0. "SG_ACLKDIV_DIS_VOTE         ,cp fabric clock divider auto disable when seagull is c2/d2    0x1 = when seagull is in c2/d2, cp fabric clock divider is automatically disabled" "0,1"

group d:0xD0201880++0x03
    line.long 0x00 "DVC_CP,<var Processor: Comm> Dynamic Voltage Change Register"
        bitfld.long 0x00 31. " VC_INT305                   ,dvc interrupt status   0x1=dvc interrupt   0x0=no dvc interrupt" "0,1"
        bitfld.long 0x00 30. "         VC_INT_EN306                 ,enable/disable dvc interrupt   0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 29. "         VC_INT_CLR307                  ,clear the dvc interrupt.this bit is auto cleared when interrupt is cleared   0x1= clear interrupt" "0,1"
        bitfld.long 0x00 23. "     LPM_D2_AVC_EN                     ,automatic voltage change enable in low power mode  0 = automatic voltage change is disabled  1 = automatic voltage change is enabled  when comm_top enters or exits d2 mode,  hardware automatically triggers a voltage change request" "0,1"
        textline "                                "
        bitfld.long 0x00 16.--19. "LPM_D2_VL3:0                ,required voltage level by  in d2 low power mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 15. "        VC_REQ312                    ,voltage change request in active mode  software can write 1 to this bit to trigger a voltage change request. hardware will automaticly clear this bit when dvc is done. writes of 0 to this bit are ignored." "0,1"
        bitfld.long 0x00 8.--11. "         VL3:0314                       ,voltage level in active mode  required voltage level by <var processor: comm> in active mode  this voltage level can be dynamically changed due to a frequency change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7. "    LPM_C2_AVC_EN                     ,automatic voltage change enable in low power mode  0 = automatic voltage change is disabled  1 = automatic voltage change is enabled  when <var processor: comm> enters or exit c2 mode,  hardware automatically triggers a voltage change request" "0,1"
        textline "                                "
        bitfld.long 0x00 0.--3. "LPM_C2_VL3:0                ,required voltage level  in cp c2 low power mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD0201884++0x03
    line.long 0x00 "DVC_DP,"
        bitfld.long 0x00 31. " VC_INT323                   ,dvc interrupt status   0x1=dvc interrupt   0x0=no dvc interrupt" "0,1"
        bitfld.long 0x00 30. "         VC_INT_EN324                 ,enable/disable dvc interrupt   0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 29. "         VC_INT_CLR325                  ,clear the dvc interrupt.this bit is auto cleared when interrupt is cleared   0x1= clear interrupt" "0,1"
        bitfld.long 0x00 15. "     VC_REQ327                         ,voltage change request in active mode  software can write 1 to this bit to trigger a voltage change request. hardware will automaticly clear this bit when dvc is done. writes of 0 to this bit are ignored." "0,1"
        textline "                                "
        bitfld.long 0x00 8.--11. "VL3:0329                    ,voltage level in active mode  required voltage level by msa in active  mode  this voltage level can be dynamically changed due to a frequency change." "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 7. "        CP_PM_LPM_AVC_EN330          ,automatic voltage change enable in low power mode  0 = automatic voltage change is disabled  1 = automatic voltage change is enabled  when msa enters or exit c2 mode,  hardware automatically triggers a voltage change request" "0,1"
        bitfld.long 0x00 0.--3. "         CP_PM_LPM_VL3:0332             ,required voltage level  in dp c2 low power mode" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD0201888++0x03
    line.long 0x00 "DVC_STATUS,Dynamic Voltage Change Status Register"
        bitfld.long 0x00 24.--27. " CP_PM_CAUSE340              ,dvc cause  this field is the cause of the current ongoing dvc. it is only valid when the <voltage change status> field is 1.   0x1 = <var processor: application mp> software-triggered dvc  0x2 = <var processor: comm> software- triggered dvc   0x4 = <var processor: msa> software- triggered dvc    0x8 = hw-dfc triggered dvc    others = lpm entry/exit trigger dvc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "        CP_PM_TVL3:0342              ,target voltage level of vcc_main" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "        CP_PM_CVL3:0344                ,current voltage level of vcc_main" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0. "    CP_PM_DVC_STATUS346               ,voltage change status  the voltage change may be triggered in active state or entering low power mode.  0 = there is no voltage change or a voltage change has finished  1 = voltage change is in progress" "0,1"

group d:0xD0201890++0x03
    line.long 0x00 "DFC_CP,<var Processor: Comm> DCLK Dynamic Freq Change Control Register"
        bitfld.long 0x00 31. " DFC_INT353                  ,dfc interrupt status   0x1=dfc interrupt   0x0=no dfc interrupt" "0,1"
        bitfld.long 0x00 30. "         DFC_INT_EN354                ,enable/disable dfc interrupt   0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 29. "         DFC_INT_CLR355                 ,clear the dfc interrupt. this bit is auto cleared when interrupt is cleared   0x1= clear interrupt" "0,1"
        bitfld.long 0x00 15. "     DCLK_FC_VOTE357                   ,dfc/dclk frequency change voting bits   0x1 = cp allows dclk /dfc frequency change   0x0 = cp disallows dclk /dfc frequency change" "0,1"
        textline "                                "
        bitfld.long 0x00 12.--14. "LPM_D2_FL                   ,required dclk freq level by comm_top d2 low power mode" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 9.--11. "         LPM_C2_FL                    ,required dclk freq level by <var processor: comm> c2 low power mode" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 8. "         LPM_C2_DFC_EN                  ,dclk hardware freq change enable upon c2 low power mode exit/entry   0 = dclk hw-dfc is disabled upon c2 mode entry/exit  1 = dclk hw-dfc is enabled upon c2 mode entry/exit" "0,1"
        bitfld.long 0x00 7. "     LPM_D2_DFC_EN                     ,dclk hardware freq change enabled upon comm_top d2 low power mode exit/entry   0 = dclk hw-dfc is disabled upon comm_top d2 mode entry/exit  1 = dclk hw-dfc is enabled upon comm_top d2 mode entry/exit" "0,1"
        textline "                                "
        bitfld.long 0x00 1.--3. "CP_PM_FL363                 ,dclk freq level in active mode  required dclk freq level by <var processor: comm> in ative mode" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0. "         CP_PM_DFC_REQ364             ,dclk dfc request in active mode   dclk dfc for <var processor: comm> in active  mode  software can write 1 to this bit to trigger a dclk dfc request. hardware will automaticly clear this bit when dfc is done. writes of 0 to this bit are ignored." "0,1"

group d:0xD0201894++0x03
    line.long 0x00 "DFC_DP,<var Processor: MSA> DCLK Dynamic Freq Change Control Register"
        bitfld.long 0x00 31. " DFC_INT371                  ,dfc interrupt status   0x1=dfc interrupt   0x0=no dfc interrupt" "0,1"
        bitfld.long 0x00 30. "         DFC_INT_EN372                ,enable/disable dfc interrupt   0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 29. "         DFC_INT_CLR373                 ,clear the dfc interrupt. this bit is auto cleared when interrupt is cleared   0x1= clear interrupt" "0,1"
        bitfld.long 0x00 15. "     DCLK_FC_VOTE375                   ,dfc/dclk frequency change voting bits   0x1 = <var processor: msa> allows dclk /dfc frequency change   0x0 = <var processor: msa> disallows dclk /dfc frequency change" "0,1"
        textline "                                "
        bitfld.long 0x00 9.--11. "LPM_FL                      ,required dclk freq level by <var processor: seagull/msa> in c2 low power mode" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 8. "         LPM_DFC_EN                   ,dclk hardware freq change enable upon low power mode exit/entry   0 = dclk dfc is disabled upon c2 mode entry/exit  1 = dclk dfc request is enabled. when both <var processor: comm> and msa enters c2 mode or when either <var processor: comm> or msa exits c2 mode, dfc request will automatically be triggered" "0,1"
        bitfld.long 0x00 1.--3. "         CP_PM_FL380                    ,dclk freq level in active mode  required dclk freq level by <var processor: comm> in ative mode" "0,1,2,3,4,5,6,7"
        bitfld.long 0x00 0. "     CP_PM_DFC_REQ381                  ,dclk dfc request in active mode   dclk dfc for <var processor: comm> in active  mode  software can write 1 to this bit to trigger a dclk dfc request. hardware will automaticly clear this bit when dfc is done. writes of 0 to this bit are ignored." "0,1"

group d:0xD0201898++0x03
    line.long 0x00 "DFC_STATUS,DCLK Hardware Freq Change Status Register"
        bitfld.long 0x00 15.--17. " CP_PM_DFC_CAUSE389          ,dclk dfc cause  this field is the cause of the current ongoing dfc. it is only valid when the <dclk_dfc_status> field is 1.   0x1 = <var processor: application mp> triggered dfc  0x2 = <var processor: comm>  triggered dfc in active mode  0x4 = <var processor: msa>  triggered dfc in active mode   others   = lpm entry/exit trigger dfc" "0,1,2,3,4,5,6,7"
        hexmask.long.byte 0x00 8.--14. 1. "         CP_PM_TFL390                 ,target freq level of dclk"
        hexmask.long.byte 0x00 1.--7. 1. "        CP_PM_CFL391                   ,current freq level of dclk"
        bitfld.long 0x00 0. "    CP_PM_DFC_STATUS392               ,dclk dfc status  the dclk dfc may be triggered in active state or <var processor: seagull/msa> entering low power mode.  0 = there is no dfc or dfc has finished  1 = dfc is in progress" "0,1"

group d:0xD020189C++0x03
    line.long 0x00 "_DEBUG, Debug Register"
        bitfld.long 0x00 1. " MASK_DVC_CHECK              ,mask dvc check in por13 state machine   0 = check is enabled   1 = check is disabled" "0,1"
        bitfld.long 0x00 0. "         MASK_SG_IDLE_CHECK           ,mask <var processor: comm> idle check in por13 state machine   0 = check is enabled   1 = check is disabled" "0,1"

group d:0xD02018A0++0x03
    line.long 0x00 "CP_S_GATE_CTRL,cp source clock gating"
        hexmask.long 0x00 5.--31. 1. " CP_PM_408                   ,reserved"
        bitfld.long 0x00 4. "  CP_PM_409                    ,1: disable 499m source clock when d2" "0,1"
        bitfld.long 0x00 3. "         CP_PM_410                      ,1: disable 624m source clock when d2" "0,1"
        bitfld.long 0x00 2. "     CP_PM_411                         ,1: disable 832m source clock when d2" "0,1"
        textline "                                "
        bitfld.long 0x00 1. "CP_PM_412                   ,1:disable 416m source clock when d2" "0,1"
        bitfld.long 0x00 0. "         CP_PM_413                    ,1:disable 312m source clock when d2" "0,1"

group d:0xD02018A4++0x03
    line.long 0x00 "CR7_INIT_CFG,CR7 init configuration"
        hexmask.long.word 0x00 22.--31. 1. " CP_PM_420                   ,reserved"
        bitfld.long 0x00 21. "      CPUCLKOFF_MASK               ,   1 = enable cpuclkoff control during cpu boot.    0 = cpuclkoff never asserted during cpu boot" "0,1"
        bitfld.long 0x00 20. "         DBGCLKOFF_MASK                 ,   1 = enable dbgclkoff control    0 = dbgclkoff never asserted during cpu boot" "0,1"
        bitfld.long 0x00 19. "     CP_PM_CFGEND423                   ,cr7 cfgend input" "0,1"
        textline "                                "
        bitfld.long 0x00 18. "CP_PM_CFGEND424             ,cr7 cfgnmfi input" "0,1"
        bitfld.long 0x00 17. "         CP_PM_VINITHI425             ,cr7 vinithi input" "0,1"
        bitfld.long 0x00 16. "         INITRAM0                       ,cr7 initram0 input" "0,1"
        bitfld.long 0x00 15. "     CP_PM_TEINIT427                   ,cr7 teinit input" "0,1"
        textline "                                "
        bitfld.long 0x00 14. "CP_PM_DBGEN428              ,cr7 dbgen input" "0,1"
        bitfld.long 0x00 13. "         CP_PM_NIDEN429               ,cr7 niden input" "0,1"
        bitfld.long 0x00 12. "         L2C_S1_CLKEN                   ,this bit must be set to 0 when cr7 configure the pl310." "0,1"
        bitfld.long 0x00 11. "     CP_PM_SPNIDEN431                  ,cr7 spniden input" "0,1"
        textline "                                "
        hexmask.long.word 0x00 0.--10. 1. "CP_PM_432                   ,reserved"

group d:0xD02018A8++0x03
    line.long 0x00 "CSWER,Communication Subsystem general purpose wakeup enable"
        bitfld.long 0x00 15. " CP_PM_441                   ,allow ripc interrupts as wakeup source   1 = allow ripc interrupt as wakeup source when cwesr_wake_en is asserted <0>not allow ripc interrupt as wakeup source" "0,1"
        bitfld.long 0x00 14. "         CP_PM_442                    ,allow cp timer3 interrupt as wakeup source   1 = allow cp timer3 interrupt as wakeup source when cwesr_wake_en is asserted <0>not allow cp timer3 interrupt as wakeup source" "0,1"
        bitfld.long 0x00 13. "         CP_PM_443                      ,allow cp timer2 interrupt as wakeup source   1 = allow cp timer2 interrupt as wakeup source when cwesr_wake_en is asserted <0>not allow cp timer2 interrupt as wakeup source" "0,1"
        bitfld.long 0x00 12. "     CP_PM_444                         ,allow dap as wakeup source   1 = allow dap as wakeup source when cwesr_wake_en is asserted <0>not allow dap as wakeup source" "0,1"
        textline "                                "
        bitfld.long 0x00 11. "CP_PM_445                   ,allow gpio as wakeup source   1 = allow gpio as wakeup source when cwesr_wake_en is asserted <0>not allow gpio as wakeup source" "0,1"
        bitfld.long 0x00 10. "         CP_PM_446                    ,allow icusb as wakeup source   1 = allow icusb as wakeup source when cwesr_wake_en is asserted <0>not allow icusb timer interrupt as wakeup source" "0,1"
        bitfld.long 0x00 8. "         CP_PM_448                      ,allow airq interrupt as wakeup source   1 = allow airq interrupt as wakeup source when cwesr_wake_en is asserted <0>not allow airq timer interrupt as wakeup source" "0,1"
        bitfld.long 0x00 7. "     CP_PM_449                         ,allow ipc interrupt from ap as wakeup source   1 = allow ipc interrupt from ap as wakeup source when cwesr_wake_en is asserted <0>not allow ipc interrupt from ap as wakeup source" "0,1"
        textline "                                "
        bitfld.long 0x00 6. "CP_PM_450                   ,allow cp timer1 interrupt as wakeup source   1 = allow cp timer1 interrupt as wakeup source when cwesr_wake_en is asserted <0>not allow cp timer1 interrupt as wakeup source" "0,1"
        bitfld.long 0x00 5. "         CP_PM_451                    ,allow pmic interrupt as wakeup source   1 = allow pmic interrupt as wakeup source when cwesr_wake_en is asserted <0>not allow pmic interrupt as wakeup source" "0,1"
        bitfld.long 0x00 4. "         CP_PM_452                      ,allow soc watchdog as wakeup source   1 = allow soc watchdog as wakeup source when cwesr_wake_en is asserted <0>not allow soc watchdog as wakeup source" "0,1"
        bitfld.long 0x00 0. "     CP_PM_454                         ,allow cgpio as wakeup source   1 = allow cgpio as wakeup source when cwesr_wake_en is asserted <0>not allow cgpio as wakeup source" "0,1"

group d:0xD02018AC++0x03
    line.long 0x00 "CSWCR,Communication Subsystem general wakeup global enable"
        bitfld.long 0x00 31. " RESET_WAKEUP_EVENT          ,reset the maskable wakeup events to cp_  1 = wakeup events are reset   0 = wakeup events are kept" "0,1"
        bitfld.long 0x00 30. "         CWESR_WAKE_EN                ,the global wake enable signal for general purpose wakeup events   1 = enabled   0 = disabled" "0,1"
        bitfld.long 0x00 29. "         D2_EXIT_STICKY_CLR             ,  1 = clear d2_exit_sticky" "0,1"
        bitfld.long 0x00 28. "     D2_EXIT_STICKY                    ," "0,1"
        textline "                                "
        bitfld.long 0x00 20. "CAPTURED_UWU                ,status of un-maskable wakeup sources" "0,1"
        bitfld.long 0x00 15. "         CP_PM_469                    ,status of ripc wakeup" "0,1"
        bitfld.long 0x00 14. "         C_TIMER_3_IRQ                  ,status of c timer3 wakeup" "0,1"
        bitfld.long 0x00 13. "     C_TIMER_2_IRQ                     ,status of c timer2 wakeup" "0,1"
        textline "                                "
        bitfld.long 0x00 12. "CP_PM_472                   ,status of dap wakeup" "0,1"
        bitfld.long 0x00 11. "         M1_GPIO_INT_CP               ,status of gpio wakeup" "0,1"
        bitfld.long 0x00 10. "         SPH_USB_WAKEUP                 ,status of ic_usb wakeup" "0,1"
        bitfld.long 0x00 9. "     IPC1_S2A_INT_0                    ,status of ipc wakeup, no used" "0,1"
        textline "                                "
        bitfld.long 0x00 8. "AIRQ                        ,status of airq wakeup" "0,1"
        bitfld.long 0x00 7. "         IPC0_S2A_INT_0               ,status of ipc wakeup from ap" "0,1"
        bitfld.long 0x00 6. "         C_TIMER_1_IRQ                  ,status of c timer1 wakeup" "0,1"
        bitfld.long 0x00 5. "     M1_WUCR_PMIC_WAKEUP_INT           ,status of pmic wakeup" "0,1"
        textline "                                "
        bitfld.long 0x00 4. "M1_WDT_IRQ                  ,status of watchdog wakeup" "0,1"
        bitfld.long 0x00 3. "         M1_CRXD_WAKEUP_INT           ,not used" "0,1"
        bitfld.long 0x00 2. "         M1_GSSP1_WAKEUP                ,not used" "0,1"
        bitfld.long 0x00 1. "     M1_I2C_WAKEUP_INT                 ,status of i2c wakeup" "0,1"
        textline "                                "
        bitfld.long 0x00 0. "M1_CGPIO_WAKEUP_MASK_OR     ,status of cgpio wakeup, not used" "0,1"

group d:0xD02018B0++0x03
    line.long 0x00 "SPH_USB_WK,ICUSB wakeup source control register "
        bitfld.long 0x00 3. " SPH_DM_WK_CLR               ,1=clear icusb dm wakeup source" "0,1"
        bitfld.long 0x00 2. "         SPH_DP_WK_CLR                ,1= clear icusb dp wakeup source" "0,1"
        bitfld.long 0x00 1. "         SPH_DM_WK_EN                   ,1= enable icusb dm wakeup" "0,1"
        bitfld.long 0x00 0. "     SPH_DP_WK_EN                      ,1= enable icusb dp wakeup" "0,1"

group d:0xD02018BC++0x03
    line.long 0x00 "CPSR,Marvell <var Processor: Comm> Power Status Register"
        bitfld.long 0x00 31. " CP_PM_DSPIDL504             ,reflects the state of the marvell msa core (not marvell msa subsystem). the availability of the marvell msa subsystem memories and peripheral bus to the marvell <var processor: comm> core is still governed by means of mpcrx[dspsd], and is not reflected by this bit.  0 = marvell msa core is currently not in idle state  1 = marvell msa core is currently in idle state" "0,1"
        bitfld.long 0x00 28. "         CP_PM_DSPAVL506              ,marvell msa subsystem availability indication. this field should be read after mpcrx[dspsd] is deasserted, to verify the clock is resumed  0 = marvell msa subsystem clock is not running  1 = marvell msa subsystem clock is running" "0,1"
        bitfld.long 0x00 24. "         CP_PM_COMM_TOP_D2508           ,reflects the power state of comm_top   1 = comm_top is in d2 mode. in this mode, msa/seagull are powered off" "0,1"
        bitfld.long 0x00 5. "     SG_WFI_FLAG                       , seagull wfi flag. it reflects the wfi flag that is directly output from seagull. when seagull enters wfi, this field will be set." "0,1"
        textline "                                "
        bitfld.long 0x00 4. "CP_PM_SG_IDLE511            ,1 = <var processor: comm> is idle   0 = <var processor: comm> is active" "0,1"
        bitfld.long 0x00 0.--3. "         CP_PM_COMM_TOP_STATE512      ,comm_top low power state   0x8=comm_top is in d0 state    0xb=comm_top is in d2 state" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD02018C0++0x03
    line.long 0x00 "CPRR,Marvell <var Processor: Comm> Programmable Reset Register"
        bitfld.long 0x00 6. " CP_PM_SLAVE_R521            ,slave_reset_out pin sw reset control  1 = slave_reset_out is low.  0 = slave_reset_out may be high base on reset_in and wdt reset." "0,1"
        bitfld.long 0x00 5. "         CP_PM_DSRAMINT522            ,this signal hold the msa from start execution after released from reset. it will be used to hold msa from start execution till his boot address in sram will be initial with valid code.  1 = execution is hold  0 = msa is running" "0,1"
        bitfld.long 0x00 4. "         WDTR523                        ,negate hardware reset to the wdt after system reset. this field is reset due to a wdt reset event  reading 0 = wdt reset is still asserted from the last system reset  reading 1 = wdt reset is negated  writing 0 = operation is ignored  writing 1 = negates the wdt reset  the actual release of the wdt reset signal might be delayed by up to 11/2 cycles of the 32.768 khz clock" "0,1"
        bitfld.long 0x00 3. "     CP_PM_BBR524                      ,apply global hardware reset to the baseband logic  0 = hardware reset is negated  1 = hardware reset is asserted  the baseband logic reset is effected also from dprr register." "0,1"
        textline "                                "
        bitfld.long 0x00 2. "CP_PM_DSPR525               ,apply global hardware reset to the whole marvell msa subsystem.  0 = hardware reset is negated - msa subsystem is released from reset.  1 = hardware reset is asserted - msa subsystem is hold in reset" "0,1"
        bitfld.long 0x00 1. "         CP_PM_APR526                 ,apply hardware reset to the application processor .  0 = hardware reset is negated - core is released from reset.  1 = hardware reset is asserted - core is hold in reset.  the initial value of this bit is determined by cp_wf_fuse not  cp_wf_fuse = 1 (<var processor: comm> core is the first one to boot).  cp_wf_fose not is 0 when <var processor: comm> wakeup first" "0,1"
        bitfld.long 0x00 0. "         CP_PM_CPR527                   ,this is read only bit, depending on cp_wf_fuse   0 = <var processor: comm> core was the first core to boot  1 = <var processor: comm> core was the second core to boot." "0,1"

group d:0xD02018C4++0x03
    line.long 0x00 "CPCR,Marvell <var Processor: Comm> Power Control Register"
        bitfld.long 0x00 31. " CP_PM_AXISDD535             ,allow axi bus and agents to be shut down after marvell <var processor: comm> cores enters idle state.  0  axi shutdown not allowed  1 = axi shutdown allowed" "0,1"
        bitfld.long 0x00 30. "         CP_PM_DSPSD536               ,not used" "0,1"
        bitfld.long 0x00 29. "         CP_PM_SLPEN537                 ,allow  to switch the system to sleep mode once it reached system idle mode.  0  sleep mode not allowed  1 = sleep mode allowed" "0,1"
        bitfld.long 0x00 28. "     DTCMSD538                         ,allow dtcm access path from main axi to be shut down when marvell <var processor: comm> core enters idle state.  0  dtcm path shutdown not allowed  1 = dtcm shutdown allowed" "0,1"
        textline "                                "
        bitfld.long 0x00 27. "CP_PM_DDRCORSD539           ,allow marvell <var processor: comm>/mohawk core and tc ddr clocks shutdown. the clocks are halted when cpcr[ddrcorsd], apcr[ddrcorsd] & dpcr[ddrcorsd] are set and marvell mohawk core is in idle mode   0  marvell <var processor: comm> core and tc ddr clocks shutdown not allowed  1 = marvell <var processor: comm>/mohawk core and tc ddr clocks shutdown allowed" "0,1"
        bitfld.long 0x00 26. "         CP_PM_APBSD540               ,allow  to shut down apb clock to all of its recipients, overriding other per-module fields. the apb clock is actually shut down once the marvell <var processor: comm> & mohawk cores are idle and cpcr[apbsd], apcr[apbsd] & dpcr[apbsd] are set  0 = apb clock shutdown not allowed  1 = apb clock shutdown allowed" "0,1"
        bitfld.long 0x00 25. "         CP_PM_BBSD541                  ,allow  to shut down all clocks provided to the baseband logic, except 32.768 khz clock. the baseband logic clocks are halted as soon as cpcr[bbsd], apcr[bbsd] & dpcr[bbsd] are set and pm_bb_clkres port is negated.  0 = bb clocks shutdown not allowed  1 = bb clocks shutdown allowed" "0,1"
        bitfld.long 0x00 24. "     CP_PM_INTCLR542                   ,interrupt clear register.   a write of 1 followed by a write of 0 to this field clears the pm_moh_wakeup_int output of .  the read value is the last value written to this field." "0,1"
        textline "                                "
        bitfld.long 0x00 23. "CP_PM_SLPWP0543             ,sleep mode wake-up decoder port 0 disable  0 = wake-up port 0 is enabled  1 = wake-up port 0 is disabled" "0,1"
        bitfld.long 0x00 22. "         CP_PM_SLPWP1544              ,sleep mode wake-up decoder port 1 disable  0 = wake-up port 1 is enabled  1 = wake-up port 1 is disabled" "0,1"
        bitfld.long 0x00 21. "         CP_PM_SLPWP2545                ,sleep mode wake-up decoder port 2 disable  0 = wake-up port 2 is enabled  1 = wake-up port 2 is disabled" "0,1"
        bitfld.long 0x00 20. "     CP_PM_SLPWP3546                   ,sleep mode wake-up decoder port 3 disable  0 = wake-up port 3 is enabled  1 = wake-up port 3 is disabled" "0,1"
        textline "                                "
        bitfld.long 0x00 19. "CP_PM_VCTCXOSD547           ,allow vctcxo shutdown when system is in sleep mode. vctcxo is shutdown when cpcr[vctcxosd], apcr[vctcxosd] & dpcr[vctcxosd] are set & the system enters sleep mode  0 = vctcxo shutdown not allowed  1 = vctcxo shutdown allowed" "0,1"
        bitfld.long 0x00 18. "         CP_PM_SLPWP4548              ,sleep mode wake-up decoder port 4 disable  0 = wake-up port 4 is enabled  1 = wake-up port 4 is disabled" "0,1"
        bitfld.long 0x00 17. "         CP_PM_SLPWP5549                ,sleep mode wake-up decoder port 5 disable  0 = wake-up port 5 is enabled  1 = wake-up port 5 is disabled" "0,1"
        bitfld.long 0x00 16. "     CP_PM_SLPWP6550                   ,sleep mode wake-up decoder port 6 disable  0 = wake-up port 6 is enabled  1 = wake-up port 6 is disabled" "0,1"
        textline "                                "
        bitfld.long 0x00 15. "CP_PM_SLPWP7551             ,sleep mode wake-up decoder port 7 disable  0 = wake-up port 7 is enabled  1 = wake-up port 7 is disabled" "0,1"
        bitfld.long 0x00 14. "         CP_PM_MSASLPEN552            ,allow msa to switch msa subsystem to sleep mode once it reached msa sub system idle mode.the sleep mode is allowed when cpcr[msaslpen], apcr[msaslpen] & dpcr[msaslpen]  0 = msa sleep mode not allowed  1 = msa sleep mode allowed  base on the c setting, msa subsystem may be powered down." "0,1"
        bitfld.long 0x00 13. "         CP_PM_STBYEN553                ,allow apps subsystem to shutdown and go into udr-mode when ap subsystem is in sleep mode.  udr is enabled when cpcr[stbyen], apcr[stbyen] are both set & ap subsystem enters ap sleep." "0,1"
        bitfld.long 0x00 3. "     CP_VOTE_AP_SLPEN                  ,cp vote apmu sleep enable" "0,1"

group d:0xD02018C8++0x03
    line.long 0x00 "CCGR,Marvell <var Processor: Comm> Clock Gating Register"
        bitfld.long 0x00 19. " CP_PM_WDT_13M565            ,enable the functional 13 mhz clock output of the main  to the watchdogtimer.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 16. "         CP_PM_CLK_1248M567           ,enable the functional 1248 mhz clock output.   0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 15. "         CP_PM_CLK_624M568              ,enable the functional 624 mhz clock output.   0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 14. "     CP_PM_CLK_832M569                 ,enable the functional 832 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        textline "                                "
        bitfld.long 0x00 13. "CP_PM_CLK_312M570           ,enable the functional 312 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 12. "         CP_PM_CLK_104M571            ,enable the functional 104 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 11. "         CLK_52M572                     ,enable the functional 52 mhz clock output for ap pmu and ap perihrals.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 10. "     CP_PM_CLK_48M573                  ,enable the functional 48 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        textline "                                "
        bitfld.long 0x00 9. "CP_PM_GPC574                ,enable the m/n clock generator of the vcxo clockconfigured through gpcr, the clcok is output to vcxo_out pad func3  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 8. "         CP_PM_AP_FUART575            ,enable the functional fast uart clock output (58.5 mhz) of the main  to the application processor apb portion.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 7. "         CLK_52M576                     ,enable the functional 52 mhz clock output for apb peripherals  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 6. "     CP_PM_AP_TWSI577                  ,enable the 32m clock of the functional twsi clock output of the main  to the application processor apb portion.  0 = clock not enabled  1 = clock enabled" "0,1"
        textline "                                "
        bitfld.long 0x00 5. "CP_PM_CLK_208M578           ,enable the functional 208 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 4. "         CP_PM_CLK_26M579             ,enable the functional 26 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 3. "         CP_PM_CLK_13M580               ,enable the functional 13 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        bitfld.long 0x00 2. "     CP_PM_CLK_6.5M581                 ,enable the functional 6.5 mhz clock output.  0 = clock not enabled  1 = clock enabled" "0,1"
        textline "                                "
        bitfld.long 0x00 1. "CP_PM_AP_SUART582           ,enable the functional m/n slow uart clock output (configured through succr) of the main  to the application processor apb portion. it's just uart slow clock(14.17m) source enable   0 = clock not enabled  1 = clock enabled." "0,1"
        bitfld.long 0x00 0. "         CP_PM_CLK_416M583            ,enable the functional 416 mhz clock output.   0 = clock not enabled  1 = clock enabled" "0,1"

group d:0xD02018CC++0x03
    line.long 0x00 "CWUCRM,Wakeup and Clock Resume Lines Mask Register"
        bitfld.long 0x00 31. " CP_PM_AUDIO_WAKEUP590       ,mask audio_wakeup" "0,1"
        bitfld.long 0x00 30. "         CP_PM_AP_GT_WAKEUP591        ,mask ap generic timer wakeup" "0,1"
        bitfld.long 0x00 29. "         CP_PM_GSM_WAKEUPWMX592         ,mask gsm wakeup from pm_clkres" "0,1"
        bitfld.long 0x00 28. "     CP_PM_FB_WAKEUPX593               ,mask fb wakeup from pm_clkres" "0,1"
        textline "                                "
        bitfld.long 0x00 27. "CP_PM_GSM_WAKEUPWM594       ,mask gsm wakeup from msa_wake" "0,1"
        bitfld.long 0x00 26. "         CP_PM_FB_WAKEUPWM595         ,mask fb wakeup rom msa_wake" "0,1"
        bitfld.long 0x00 25. "         AP_ASYNC_INT596                ,mask ap async int from pm_clkres" "0,1"
        bitfld.long 0x00 24. "     AP_FULL_IDLE597                   ,mask ap full idle from pm_clkres" "0,1"
        textline "                                "
        bitfld.long 0x00 23. "SDH1_AUDIO598               ,mask sdh1/audio wakeup" "0,1"
        bitfld.long 0x00 22. "         SDH2599                      ,mask sdh2 wakeup" "0,1"
        bitfld.long 0x00 21. "         KEYPRESS600                    ,mask keypress wakeup" "0,1"
        bitfld.long 0x00 20. "     TRACKBALL601                      ,mask trackball wakeup" "0,1"
        textline "                                "
        bitfld.long 0x00 19. "NEWROTARY602                ,mask newrotary wakeup" "0,1"
        bitfld.long 0x00 18. "         WDT603                       ,mask wdt wakeup" "0,1"
        bitfld.long 0x00 17. "         RTC_ALARM604                   ,mask rtc alarm wakeup" "0,1"
        bitfld.long 0x00 16. "     CP_TIMER_3605                     ,mask cp timer int3 wakeup" "0,1"
        textline "                                "
        bitfld.long 0x00 15. "CP_TIMER_2606               ,mask cp timer int2 wakeup" "0,1"
        bitfld.long 0x00 14. "         CP_TIMER_1607                ,mask cp timer int1 wakeup" "0,1"
        bitfld.long 0x00 13. "         AP1_TIMER_3608                 ,mask ap timer1 int3 wakeup" "0,1"
        bitfld.long 0x00 12. "     AP1_TIMER_2609                    ,mask ap timer1 int2 wakeup" "0,1"
        textline "                                "
        bitfld.long 0x00 11. "AP1_TIMER_1610              ,mask ap timer1 int1 wakeup" "0,1"
        bitfld.long 0x00 10. "         AP0_2_TIMER_3611             ,mask ap timer0 and ap timer2 int3 wakeup" "0,1"
        bitfld.long 0x00 9. "         AP0_2_TIMER_2612               ,mask ap timer0 and ap timer2 int2 wakeup" "0,1"
        bitfld.long 0x00 8. "     AP0_2_TIMER_1613                  ,mask ap timer0 and ap timer2 int1 wakeup" "0,1"
        textline "                                "
        bitfld.long 0x00 7. "WAKEUP7614                  ,mask wakeup7 input to pm_clkres" "0,1"
        bitfld.long 0x00 6. "         WAKEUP6615                   ,mask wakeup6 input to pm_clkres" "0,1"
        bitfld.long 0x00 5. "         WAKEUP5616                     ,mask wakeup5 input to pm_clkres" "0,1"
        bitfld.long 0x00 4. "     WAKEUP4617                        ,mask wakeup4 input to pm_clkres" "0,1"
        textline "                                "
        bitfld.long 0x00 3. "WAKEUP3618                  ,mask wakeup3 input to pm_clkres" "0,1"
        bitfld.long 0x00 2. "         WAKEUP2619                   ,mask wakeup2 input to pm_clkres" "0,1"
        bitfld.long 0x00 1. "         WAKEUP1620                     ,mask wakeup1input to pm_clkres" "0,1"
        bitfld.long 0x00 0. "     WAKEUP0621                        ,mask wakeup0 input to pm_clkres" "0,1"

group d:0xD02018D0++0x03
    line.long 0x00 "CWUCRS,Wakeup and Clock Resume Lines Status Register"
        bitfld.long 0x00 31. " CP_PM_BB_DROWSY_EN628       ,bb_drowsy_en" "0,1"
        bitfld.long 0x00 30. "         CP_PM_BB_VCTCXO_REQ629       ,bb_vctcxo_req" "0,1"
        bitfld.long 0x00 29. "         CP_PM_MSA_WAKE_PM_BB_CLKRES630 ,msa_wake/pm_bb_clkres" "0,1"
        bitfld.long 0x00 28. "     CP_PM_PM_CLKRES631                ,pm_clkres" "0,1"
        textline "                                "
        bitfld.long 0x00 27. "CP_PM_GSM_WAKEUP632         ,gsm wakeup" "0,1"
        bitfld.long 0x00 26. "         CP_PM_FB_WAKEUP633           ,fb wakeup" "0,1"
        bitfld.long 0x00 25. "         AP_ASYNC_INT634                ,ap async int" "0,1"
        bitfld.long 0x00 24. "     AP_FULL_IDLE635                   ,ap full idle" "0,1"
        textline "                                "
        bitfld.long 0x00 23. "SDH1_AUDIO636               ,sdh1/audio wakeup" "0,1"
        bitfld.long 0x00 22. "         SDH2637                      ,sdh2 wakeup" "0,1"
        bitfld.long 0x00 21. "         KEYPRESS638                    ,keypress" "0,1"
        bitfld.long 0x00 20. "     TRACKBALL639                      ,trackball" "0,1"
        textline "                                "
        bitfld.long 0x00 19. "NEWROTARY640                ,newrotary" "0,1"
        bitfld.long 0x00 18. "         WDT641                       ,wdt" "0,1"
        bitfld.long 0x00 17. "         RTC_ALARM642                   ,rtc alarm" "0,1"
        bitfld.long 0x00 16. "     CP_TIMER_3643                     ,cp timer 3" "0,1"
        textline "                                "
        bitfld.long 0x00 15. "CP_TIMER_2644               ,cp timer 2" "0,1"
        bitfld.long 0x00 14. "         CP_TIMER_1645                ,cp timer 1" "0,1"
        bitfld.long 0x00 13. "         AP1_TIMER_3646                 ,ap1 timer 3" "0,1"
        bitfld.long 0x00 12. "     AP1_TIMER_2647                    ,ap1 timer 2" "0,1"
        textline "                                "
        bitfld.long 0x00 11. "AP1_TIMER_1648              ,ap1 timer 1" "0,1"
        bitfld.long 0x00 10. "         AP0_2_TIMER_3649             ,ap0 timer 3 and ap2 timer 3" "0,1"
        bitfld.long 0x00 9. "         AP0_2_TIMER_2650               ,ap0 timer 2 and ap2 timer 2" "0,1"
        bitfld.long 0x00 8. "     AP0_2_TIMER_1651                  ,ap0 timer 1 and ap2 timer 1" "0,1"
        textline "                                "
        bitfld.long 0x00 8. "WAKEUP7652                  ,wakeup7 line in status" "0,1"
        bitfld.long 0x00 6. "         WAKEUP6653                   ,wakeup6 line in status" "0,1"
        bitfld.long 0x00 5. "         WAKEUP5654                     ,wakeup5 line in status" "0,1"
        bitfld.long 0x00 4. "     WAKEUP4655                        ,wakeup4 line in status" "0,1"
        textline "                                "
        bitfld.long 0x00 3. "WAKEUP3656                  ,wakeup3 line in status" "0,1"
        bitfld.long 0x00 2. "         WAKEUP2657                   ,wakeup2 line in status" "0,1"
        bitfld.long 0x00 1. "         WAKEUP1658                     ,wakeup1 line in status" "0,1"
        bitfld.long 0x00 0. "     WAKEUP0659                        ,wakeup0 line in status" "0,1"

group d:0xD02018D4++0x03
    line.long 0x00 "CRSR,Marvell <var Processor: Comm>/Mohawk Reset Status Register"
        bitfld.long 0x00 8.--11. " CP_PM_SWR668                ,software controlled, reset events tracking field. this field may be written (and read) to any value between 0x0 and 0xf.   this field's content does not affect  functionality in any way" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 2. "        WDTR670                      ,indicates whether the last system reset was caused by a watchdog timer reset event  0 = last system reset was not caused by watchdog timer reset  1 = last system reset was caused by watchdog timer reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"
        bitfld.long 0x00 1. "         CP_PM_EMR671                   ,indicates whether the last system reset was caused by an external master reset event  0 = last system reset was not caused by external master reset  1 = last system reset was caused by external master reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"
        bitfld.long 0x00 0. "     CP_PM_POR672                      ,indicates whether the last system reset was caused by a power on reset  event  0 = last system reset was not caused by power on reset  1 = last system reset was caused by power on reset  depending on the type of reset the device has experienced, one of the reset values in [2:0] is 1 and the others are 0." "0,1"

group d:0xD02018DC++0x03
    line.long 0x00 "CUCCR,CP UART Clock and  reset Control Register"
        hexmask.long 0x00 6.--31. 1. " CP_PM_RESERVED679           ,reserved"
        bitfld.long 0x00 5. "  CP_UART_RESET_EN             ,0x1 =  reset asserted" "0,1"
        bitfld.long 0x00 4. "         CP_UART_APB_EN                 ,0x1 = clock enable" "0,1"
        bitfld.long 0x00 3. "     CP_UART_FCLK_EN                   ,0x1 =  clock enable" "0,1"
        textline "                                "
        bitfld.long 0x00 0.--2. "CP_UART_CLK_SEL             ,uart clock selection: 0x0 = fast 48mhz clock (312m div 5p3), 0x1 = slow m/n divider clock (generated by the main pmu 156m m/n divider  in succr register). other selection reserved" "0,1,2,3,4,5,6,7"

group d:0xD02018E0++0x03
    line.long 0x00 "DMA_INT_MSK,DMA Interrupt Mask Register"
        hexmask.long 0x00 0.--31. 1. " DMA_INT_MSK                 ,cp dma interrupt mask  this field contains one bit for each dma channel interrupt mask.  1 = interrupt is masked"

group d:0xD02018E4++0x03
    line.long 0x00 "DMA_INT_STATUS,DMA Interrupt Status Register"
        hexmask.long 0x00 0.--31. 1. " CP_DMA_INT_STATUS           ,cp dma interrupt status   this field contains one bit for each dma channel interrupt that is pending (after masking).    0x1= interrupt is pending"

group d:0xD02018E8++0x03
    line.long 0x00 "DMA_XTC_CTRL,DMA WTC RTC Control Register"
        bitfld.long 0x00 12.--15. " CP_DMA_WTCB                 ,cp_dma_wtcb" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "        CP_DMA_RTCB                  ,cp_dma_rtcb" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "        CP_DMA_WTC                     ,cp_dma_wtc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "    CP_DMA_RTC                        ,cp_dma_rtc" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD02018F0++0x03
    line.long 0x00 "DYN_CLK_GATE_CTRL,Dynamic Clock Gating Control"
        bitfld.long 0x00 16. " DTC_DYN_CG_EN               ,dynamic clock gating control enable for dtc.when enabled, when dtc is inatcive, dtc clkgen will be disabled to save more power    0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 5. "         CR5FAB_DYN_CG_EN             ,cr5 2x1 fabric dynamic clock gating control enable. when enable, cr5 2x1 fabric axi clock will be gated dynamically to save more power    0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 4. "         FBFAB_DYN_CG_EN                ,fb 2x1 fabric dynamic clock gating control enable. when enable, fb 2x1 fabric axi clock will be gated dynamically to save more power    0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 3. "     GBDEC_DYN_CG_EN                   ,gb decoder dynamic clock gating control enable. when enable, gb decoder axi clock will be gated dynamically to save more power    0x0=disabled    0x1=enabled" "0,1"
        textline "                                "
        bitfld.long 0x00 2. "GBPRT_DYN_CG_EN             ,cpss fabric gb port dynamic clock gating control enable. when enabled, gb port axi clock on cpss fabric will be gated dynamically to save more power    0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 1. "         CR5PRT_DYN_CG_EN             ,cpss fabric cr5 port dynamic clock gating control enable. when enabled, cr5 port axi clock on cpss fabric will be gated dynamically to save more power    0x0=disabled    0x1=enabled" "0,1"
        bitfld.long 0x00 0. "         CPFAB_DYN_CG_EN                ,cpss fabric dynamic clock gating control enable. when enabled, cpss fabric axi clock will be gated dynamically to save more power    0x0=disabled    0x1=enabled" "0,1"

group d:0xD02018F4++0x03
    line.long 0x00 "FABRIC_QoS_CTRL,Fabric QoS  Control"
        bitfld.long 0x00 28.--31. " DTC_MST_AR_QOS              ,cr5 2x1 fabric dtc master read channel qos value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 24.--27. "        DTC_MST_AW_QOS               ,cr5 2x1 fabric dtc master write channel qos value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 20.--23. "        CR5_MST_AR_QOS                 ,cr5 2x1 fabric cr5 master read channel qos value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 16.--19. "    CR5_MST_AW_QOS                    ,cr5 2x1 fabric cr5 master write channel qos value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        textline "                                "
        bitfld.long 0x00 12.--15. "GB_MST_AR_QOS               ,fb 2x1 fabric gb master read channel qos value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 8.--11. "        GB_MST_AW_QOS                ,fb 2x1 fabric gb master write channel qos value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 4.--7. "        FB_MST_AR_QOS                  ,fb 2x1 fabric fb master read channel qos value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"
        bitfld.long 0x00 0.--3. "    FB_MST_AW_QOS                     ,fb 2x1 fabric fb master write channel qos value" "0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15"

group d:0xD0201900++0x03
    line.long 0x00 "DDR_REQ_CTRL_GB,DDR Request Control Register for GB"
        hexmask.long 0x00 4.--31. 1. " CP_PM_745                   ,"
        bitfld.long 0x00 31. "  DDRC_RDY_EN746               ,  1 = 1= axi transactions to ddrc are sent without considering ddrc's status   0 =  0= axi transactions to ddrc are only sent when ddrc is ready" "0,1"
        hexmask.long.word 0x00 21.--30. 1. "         CP_PM_747                      ,"
        bitfld.long 0x00 20. "  FBDMA_DDRC_REQ_EN748              ,  0x1= if fb dma is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because fb dma's is active" "0,1"
        textline "                                "
        bitfld.long 0x00 19. "DTC_DDRC_REQ_EN749          ,  0x1= if dtc is active, request ddrc resource<p>0x0 = ddrc resource will not be requested because dtc's is active" "0,1"
